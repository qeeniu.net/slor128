# Altium PCB MD041A.PcbDoc (part 3 of 5)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 6709.84 x 5059.84 mil, 4 copper layers (Top Layer, Signal Layer 1, Signal Layer 2, Bottom Layer), stack 61.2 mil thick; 351 components, 206 nets, 927 pads, 324 vias.

## Part data (continued)
C1 C2 C3 C4 C5 C6: library part CMP-0006250-2, "CAP, CERM, 33 pF, 50 V, +/- 5%, C0G/NP0, 0402", Cap_Case=0402, Manufacturer=TDK, Supplier Part Number 1=445-1241-1-ND, TempCo=C0G/NP0, Tolerance_%=5%, Value1=Unknown, Value2=50V, ValueDisplayed=33pF
C7 C8 C9 C10 C11 C12 C15 C16 C17 C18 C21 C25 C32 C33 C34 C41 C48 C62: library part CMP-0006221-2, "CAP, CERM, 0.1 uF, 10 V, +/- 20%, X5R, 0402", Cap_Case=0402, Manufacturer="Wurth Elektronik", Supplier Part Number 1=732-7487-1-ND, TempCo=X5R, Tolerance_%=20%, Value1=Unknown, Value2=10V, ValueDisplayed=0.1uF
C13 C29: library part CMP-0097299-1, "0.47 µF ±20% 10V Ceramic Capacitor X5R 0603 (1608 Metric)", Digikey Part Number=732-7905-1-ND, Manufacturer="Wurth Electronics", Mouser Part Number=710-885012106008, Operating Temperature Range="-55°C to +85°C", TempCo=15%, Temperature Characteristic=X5R, Tolerance_%=20%, ValueDisplayed=470nF
C14 C31: library part CMP-0084376-1, "CAP, Tantalum Polymer, 10 µF, 10 V,+/- 20%, 0.08 ohm, 3216-18 SMD", Cap_Case=3216-18, Manufacturer=Kemet, Tolerance_%=20%, Value1="0.08 ohm", Value2=10V, ValueDisplayed=10µF
C19 C22 C24: library part CMP-0097306-1, "33 pF ±5% 50V Ceramic Capacitor C0G, NP0 0402 (1005 Metric)", Digikey Part Number=732-7472-1-ND, Manufacturer="Wurth Electronics", Mouser Part Number=710-885012005058, Operating Temperature Range="-55°C to +125°C", TempCo=30ppm/°C, Temperature Characteristic=NP0, Tolerance_%=5%, ValueDisplayed=33pF
C20: library part CMP-0006269-2, "CAP, CERM, 4.7 uF, 10 V, +/- 20%, X5R, 0402", Cap_Case=0402, Manufacturer=TDK, Supplier Part Number 1=445-8023-1-ND, TempCo=X5R, Tolerance_%=20%, Value1=Unknown, Value2=10V, ValueDisplayed=4.7uF
C23: library part CMP-0006231-2, "CAP, CERM, 1000 pF, 50 V, +/- 10%, X7R, 0402", Cap_Case=0402, Manufacturer="Wurth Elektronik", Supplier Part Number 1=732-7556-1-ND, TempCo=X7R, Tolerance_%=10%, Value1=Unknown, Value2=50V, ValueDisplayed=1000pF
C26 C27 C42 C43: library part CMP-0006215-2, "CAP, CERM, 10 pF, 50 V, +/- 5%, C0G/NP0, 0402", Cap_Case=0402, Manufacturer="Wurth Elektronik", Supplier Part Number 1=732-7469-1-ND, TempCo=C0G/NP0, Tolerance_%=5%, Value1=Unknown, Value2=50V, ValueDisplayed=10pF
C28 C30 C47: library part CMP-0078875-1, "CAP, CERM, 0.22 µF, 10 V,+/- 20%, X5R, 0402", Cap_Case=0402, Manufacturer="Wurth Elektronik", Supplier Part Number 1=732-7488-1-ND, TempCo=X5R, Tolerance_%=20%, Value2=10V, ValueDisplayed=0.22µF
C35 C40 C45: library part CMP-0064924-2, "CAP, CERM, 1 uF, 10 V,+/- 20%, X5R, 0402", Cap_Case=0402, Manufacturer="Wurth Elektronik", Supplier Part Number 1=732-7489-1-ND, TempCo=X5R, Tolerance_%=20%, Value1=Unknown, Value2=10V, ValueDisplayed=1uF
C36: library part CMP-0006562-2, "CAP, CERM, 0.1 uF, 10 V, +/- 10%, X5R, 0402", Cap_Case=0402, Manufacturer=MuRata, Supplier Part Number 1=490-1318-1-ND, TempCo=X5R, Tolerance_%=10%, Value1=Unknown, Value2=10V, ValueDisplayed=0.1uF
C37 C39: library part CMP-0006639-2, "CAP, CERM, 0.01 uF, 16 V, +/- 10%, X7R, 0402", Cap_Case=0402, Manufacturer=MuRata, Supplier Part Number 1=490-1313-1-ND, TempCo=X7R, Tolerance_%=10%, Value1=Unknown, Value2=16V, ValueDisplayed=0.01uF
C38: library part CMP-0006594-2, "CAP, CERM, 2.2 uF, 16 V, +/- 10%, X5R, 0402", Cap_Case=0402, Manufacturer=MuRata, Supplier Part Number 1=490-10695-1-ND, TempCo=X5R, Tolerance_%=10%, Value1=Unknown, Value2=16V, ValueDisplayed=2.2uF
C44: library part CMP-14477-003474-2, "None", Capacitance=100nF, Case/Package=Ceramic, Dielectric=X5R, Max Operating Temperature=85°C, Min Operating Temperature=-55°C, Tolerance=20%, Voltage Rating=100V
C46: library part CMP-0008271-1, "CAP, CERM, 3.3 uF, 25 V, +/- 10%, X6S, 0805", Cap_Case=0805, Manufacturer=MuRata, Supplier Part Number 1=GRM21BC81E335KA73L-ND, TempCo=X6S, Tolerance_%=10%, Value1=Unknown, Value2=25V, ValueDisplayed=3.3uF
C49 C51: library part CMP-0007873-2, "CAP, CERM, 1 uF, 50 V, +/- 10%, X7R, 0805", Cap_Case=0805, Manufacturer=TDK, Supplier Part Number 1=445-7547-1-ND, TempCo=X7R, Tolerance_%=10%, Value1="0.008782 ohm", Value2=50V, ValueDisplayed=1uF
C50 C55 C63: library part CMP-0095152-1, "0.1 µF ±10% 100V Ceramic Capacitor X7R 0603 (1608 Metric)", Digikey Part Number=732-885012206120TR-ND, Manufacturer="Wurth Electronics", Mouser Part Number=710-885012206120, Operating Temperature Range="-55°C to +125°C", TempCo=15%, Temperature Characteristic=X7R, Tolerance_%=10%, ValueDisplayed=100nF
C52 C54 C60 C61 C64 C65 C66 C74: library part CMP-0097311-1, "1000 pF ±5% 100V Ceramic Capacitor C0G, NP0 0603 (1608 Metric)", Digikey Part Number=732-12187-1-ND, Manufacturer="Wurth Electronics", Mouser Part Number=710-885012006085, Operating Temperature Range="-55°C to +125°C", TempCo=30ppm/°C, Temperature Characteristic=NP0, Tolerance_%=5%, ValueDisplayed=1nF
C53 C75: library part CMP-0094051-1, "100uF 100V 20% Aluminum Electrolytic Capacitors Radial, Can - SMD - 5000 Hrs @ 105°C", Digikey Part Number=565-2511-1-ND, Leakage Current=100uA, Manufacturer="United Chemi-Con", Mouser Part Number=661-EMVY101ARA101MKE, Operating Temperature Range="-40°C to +105°C", Tolerance_%=20%, ValueDisplayed=100uF
C56: library part CMP-0009145-2, "CAP, CERM, 1 uF, 100 V, +/- 10%, X7R, AEC-Q200 Grade 1, 1210", Cap_Case=1210_220, Manufacturer=TDK, Supplier Part Number 1=445-5865-1-ND, TempCo=X7R, Tolerance_%=10%, Value1="0.004956 ohm", Value2=100V, ValueDisplayed=1uF
C57 C58 C59: library part CMP-0079993-1, "CAP, CERM, 0.01 µF, 100 V,+/- 10%, X7R, 0603", Cap_Case=0603, Manufacturer="Wurth Elektronik", Supplier Part Number 1=45AC8565, TempCo=X7R, Tolerance_%=10%, Value2=100V, ValueDisplayed=0.01µF
C67 C68 C69 C70 C71: library part CMP-0097308-1, "100 pF ±5% 100V Ceramic Capacitor C0G, NP0 0402 (1005 Metric)", Digikey Part Number=732-12055-1-ND, Manufacturer="Wurth Electronics", Mouser Part Number=710-885012005080, Operating Temperature Range="-55°C to +125°C", TempCo=30ppm/°C, Temperature Characteristic=NP0, Tolerance_%=5%, ValueDisplayed=100pF
C72 C73: library part CMP-0006227-2, "CAP, CERM, 0.01 uF, 16 V, +/- 10%, X7R, 0402", Cap_Case=0402, Manufacturer="Wurth Elektronik", Supplier Part Number 1=710-885012205031, TempCo=X7R, Tolerance_%=10%, Value1=Unknown, Value2=16V, ValueDisplayed=0.01uF
D1: library part CMP-0002947-3, "LED, Red, SMD", Color=Red, Manufacturer="Wurth Elektronik", Power_TotalModule=72mW, Value1=0.072W, Value2=2V
D2 D4 D5 D6 D8 D10 D11: library part CMP-0002894-2, "LED, Green, SMD", Color=green, Manufacturer="Wurth Elektronik", Value1=W, Value2=2V
D3: library part CMP-1055-00457-1, "Schottky Barrier Diode, 2-Pin SOD-323, Pb-Free, Tape and Reel", Manufacturer="On Semiconductor"
D7 D12: library part CMP-0002893-1, "LED, Super Red, SMD", Color="super red", Manufacturer="Wurth Elektronik", Supplier Part Number 1=732-4979-1-ND, Value1=W, Value2=1.9V
D9: library part CMP-0002892-3, "LED, Yellow, SMD", Color=yellow, Manufacturer="Wurth Elektronik", Value1=W, Value2=2V
D10 D10 D11 D11 D12 D12: library part CMP-0002892-3, "LED, Yellow, SMD"
D13: library part CMP-0097377-1, "Diode Zener Single 4.7V 2% 550mW Automotive 2-Pin SOD-323F T/R", Digikey Part Number=1727-1672-1-ND, Forward Current=250mA, Manufacturer=Nexperia, Max Reverse Leakage Current=3uA, Mouser Part Number=771-BZX84J-B4V7,115, Operating Temperature Range="to +150°C", Power_W=550mW
F1 F2: library part CMP-0081016-1, "Fuse, 15 A, 250 VAC, 100 VDC, SMD", Irating_A=15A, Manufacturer=Littelfuse
FID1 FID2 FID3 FID4: library part CMP-0077181-1, "Fiducial mark.  There is nothing to buy or mount.", Manufacturer=N/A
H1 H2 H3 H4 H5 H6: library part CMP-0003678-1, "Standoff, Hex, 1.25\"L #6-32 Nylon", Manufacturer=Keystone
H1_Nut H2_Nut H3_Nut H4_Nut H5_Nut H6_Nut: library part CMP-0003948-1, "Small nylon hex nut, 0.10 thick with a 0.250 outside diameter and a 4-40 threading", Manufacturer=Keystone, Supplier Part Number 1=36-9605-ND
J1 J2: library part CMP-0075613-1, "Receptacle, 2.54mm, 10x2, Gold, TH", Color=Black, Current_A=6.3A, Manufacturer=Samtec, Voltage_V=550V
J3 J15 J21 J22 J24: library part CMP-0075110-1, "1mm Uninsulated Shorting Plug, 10.16mm spacing, TH", Manufacturer=Harwin, Supplier Part Number 1=952-1873-ND
J4 J8: library part CMP-0075595-1, "Header, 2.54mm, 8x2, Gold, SMT", Color=Black, Current_A=4.9A, Manufacturer=Samtec, Supplier Part Number 1=SAM8884-ND, Voltage_V=475V
J5 J6 J7 J16 J17 J18 J19 J20 J25 J26: library part CMP-0054566-1, "Header, 100mil, 2x1, Gold, TH", Color=Black, Current_A=3A, Manufacturer="Sullins Connector Solutions", Supplier Part Number 1=S1011E-02-ND, Voltage_V=1.8kV
J9 J10: library part CMP-0086014-1, "Header, 2.54mm, 7x2, Gold, TH", Color=Black, Current_A=3A, Manufacturer="Wurth Elektronik", Voltage_V=250V
J11: library part CMP-0055311-1, "Receptacle, USB 2.0, Micro B, 5 Position, R/A, SMT", Color=Black, Current_A=1.8A, Manufacturer=Molex, Supplier Part Number 1=WM11263CT-ND, Voltage_V=30V
J12: library part CMP-0086764-1, "2 Position Wire to Board Terminal Block Horizontal with Board 0.400\" (10.16mm) Through Hole", Current_A=57A, Manufacturer=Wurth, Voltage_V=750V
J13 J14 J23: library part CMP-0093233-2, "2 Position Wire to Board Terminal Block Horizontal with Board 0.250\" (6.35mm) Through Hole", Current_A=32A, Digikey Part Number=732-691250610002-ND, Manufacturer="Wurth Electronics", Mouser Part Number=710-691250610002, Operating Temperature Range="-32°C to +120°C", Voltage_V=450V
J27: library part CMP-0054796-4, "Header, 2.54 mm, 3x1, Gold, TH", Manufacturer="Wurth Elektronik", Supplier Part Number 1=732-5316-ND
L1 L2: library part CMP-0081962-1, "Ferrite Bead, 150 ohm @ 100 MHz, 0.7 A, 0603", Manufacturer=MuRata, Supplier Part Number 1=490-14035-1-ND, Value1="0.35 ohm", Value2=0.7A, ValueDisplayed="150 ohm"
LBL1: library part CMP-0003625-1, "Thermal Transfer Printable Labels, 0.650\" W x 0.200\" H - 10,000 per roll", Manufacturer=Brady, Supplier Part Number 1=97C5133
LOGO1 LOGO7: library part CMP-0074837-2, "IEC 61010-1 Hot Surface Warning", Manufacturer="Texas Instruments"
Logo2: library part CMP-0074844-1
Logo3: library part CMP-0074838-1, "Texas Instrument Corporate Signature"
Logo4: library part CMP-0074847-1, "FCC_disclaimer"
Logo5: library part CMP-0074769-3, Manufacturer="Texas Instruments"
Logo6: library part CMP-0074836-1, "IEC 61010-1 Caution Warning"
MP1: library part CMP-0096184-1, "Heat Sink Aluminum Top Mount", Digikey Part Number=ATS2180-ND, Manufacturer="Advanced Thermal Solutions", Operating Temperature Range=to, Thermal Resistance Forced Air Flow=2.2°C/W
Q1: library part CMP-1048-00779-1, "General Purpose Transistor, NPN Silicon, 3-Pin SOT-23, Pb-Free, Tape and Reel", Manufacturer="On Semiconductor"
R1 R5 R6 R7 R8 R9 R10 R11 R12 R13 R14 R15 R16 R17 R18 R21 R23 R24 R25 R26 R27 R30 R32 R33 R34 R54 R68: library part CMP-0026992-3, "RES, 0, 5%, 0.1 W, AEC-Q200 Grade 0, 0402", Manufacturer=Panasonic, PartNumber=ERJ-2GE0R00X, Power_W=100mW, Supplier Part Number 1=P0.0JCT-ND, TempCo="600 ppm/C", Tolerance_%=5%, Value2=0.1W, Value_Code=0000, ValueDisplayed=0
R2 R3: library part CMP-0025784-4, "RES, 330 k, 5%, 0.1 W, AEC-Q200 Grade 0, 0603", Manufacturer=Vishay-Dale, Power_W=100mW, Supplier Part Number 1=541-330KGCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.1W, Value_Code=330k
R4 R35: library part CMP-0091848-1, "10 Ohms ±5% 0.05W, 1/20W Chip Resistor 0402 (1005 Metric) RF, High Frequency Thin Film", Digikey Part Number=716-CH0402-10RJFPTCT-ND, Manufacturer=Vishay, Mouser Part Number=71-CH0402-10RJFPT, Operating Temperature Range="-55°C to +155°C", Power_W=50mW, TempCo=100ppm/°C, Tolerance_%=5%
R19 R44 R49: library part CMP-0021998-4, "RES, 10.0 k, 1%, 0.1 W, AEC-Q200 Grade 0, 0603", Manufacturer=Vishay-Dale, Power_W=100mW, Supplier Part Number 1=541-10.0KHCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.1W, Value_Code=10k0, ValueDisplayed=10.0k
R29 R57 R97: library part CMP-0026935-3, "RES, 47 k, 5%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-47KJCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.063W, Value_Code=47k0, ValueDisplayed=47k
R39 R40 R41 R42: library part CMP-0026071-3, "RES, 1.00 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-1.00KLCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.063W, Value_Code=1k00, ValueDisplayed=1.00k
R55 R60: library part CMP-0026728-1, "RES, 220 k, 1%, 0.0625 W, 0402", Manufacturer="Yageo America", Power_W=62.5mW, Supplier Part Number 1=311-220KLRCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.0625W, Value_Code=220k
R56: library part CMP-0026190-2, "RES, 240 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-240KLCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.063W, Value_Code=240k
R58: library part CMP-0026934-3, "RES, 470, 5%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-470JCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.063W, Value_Code=470R, ValueDisplayed=470
R59: library part CMP-0026948-3, "RES, 560, 5%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-560JCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.063W, Value_Code=560R, ValueDisplayed=560
R61: library part CMP-0026021-3, "RES, 150 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-150KLCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.063W, Value_Code=150k
R62 R63: library part CMP-0026992-3, "RES, 0, 5%, 0.1 W, AEC-Q200 Grade 0, 0402", Manufacturer=Panasonic, Power_W=100mW, Supplier Part Number 1=P0.0JCT-ND, TempCo="600 ppm/C", Tolerance_%=5%, Value2=0.1W, Value_Code=0000, ValueDisplayed=0
R64 R65 R66 R67: library part CMP-0025963-3, "RES, 10.0, 1%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-10.0LCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.063W, Value_Code=10R0, ValueDisplayed=10.0
R69 R70: library part CMP-0025697-4, "RES, 0, 5%, 0.1 W, AEC-Q200 Grade 0, 0603", Manufacturer=Vishay-Dale, PartNumber=CRCW06030000Z0EA, Power_W=100mW, Supplier Part Number 1=541-0.0GCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.1W, Value_Code=0000, ValueDisplayed=0
R71 R72 R73 R75: library part CMP-0026888-3, "RES, 27, 5%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-27JCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.063W, Value_Code=27R0, ValueDisplayed=27
R74: library part CMP-2002-00429-1, Manufacturer=Panasonic, Part Number=ERJ-2GE0R00X
R76: library part CMP-0026085-3, "RES, 1.40 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-1.40KLCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.063W, Value_Code=1k40, ValueDisplayed=1.40k
R77: library part CMP-0026859-2, "RES, 1.0 M, 5%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-1.0MJCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.063W, Value_Code=1M00, ValueDisplayed=1.0M
R78: library part CMP-0026907-3, "RES, 33 k, 5%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-33KJCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.063W, Value_Code=33k0, ValueDisplayed=33k
R79 R80 R81 R82: library part CMP-0026695-1, "RES, 3.30 k, 1%, 0.1 W, AEC-Q200 Grade 0, 0402", Manufacturer=Panasonic, Power_W=100mW, Supplier Part Number 1=P3.30KLCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.1W, Value_Code=3k30, ValueDisplayed=3.30k
R83 R88 R99 R100 R101 R102 R103 R105 R106 R107 R108 R109: library part CMP-0025886-5, "RES, 10 k, 5%, 0.1 W, 0603", Manufacturer=Yageo, Power_W=100mW, Supplier Part Number 1=311-10KGRCT-ND, TempCo="100 ppm/C", Tolerance_%=5%, Value2=0.1W, Value_Code=10k0, ValueDisplayed=10k
R84 R85 R86 R87: library part CMP-0081856-1, "RES, 0, 0%, 0.2 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=200mW, Supplier Part Number 1=541-0.0YBTR-ND, Tolerance_%=0%, Value2=0.2W, Value_Code=0
R89 R90 R91 R92: library part CMP-0022628-4, "RES, 86.6 k, 1%, 0.1 W, AEC-Q200 Grade 0, 0603", Manufacturer=Vishay-Dale, Power_W=100mW, Supplier Part Number 1=541-86.6KHCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.1W, Value_Code=86k6, ValueDisplayed=86.6k
R93 R94 R95 R96 R104: library part CMP-0022458-4, "RES, 4.99 k, 1%, 0.1 W, AEC-Q200 Grade 0, 0603", Manufacturer=Vishay-Dale, Power_W=100mW, Supplier Part Number 1=541-4.99KHCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.1W, Value_Code=4k99, ValueDisplayed=4.99k
R98: library part CMP-0022663-4, "RES, 97.6 k, 1%, 0.1 W, AEC-Q200 Grade 0, 0603", Manufacturer=Vishay-Dale, Power_W=100mW, Supplier Part Number 1=541-97.6KHCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.1W, Value_Code=97k6, ValueDisplayed=97.6k
R110: library part CMP-0023183-5, "RES, 560, 1%, 0.1 W, 0603", Manufacturer=Yageo, Power_W=100mW, Supplier Part Number 1=311-560HRCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.1W, Value_Code=560R, ValueDisplayed=560
R111 R112 R113 R114 R115 R116 R117: library part CMP-0025785-4, "RES, 330, 5%, 0.1 W, AEC-Q200 Grade 0, 0603", Manufacturer=Vishay-Dale, PartNumber=CRCW0603330RJNEA, Power_W=100mW, Supplier Part Number 1=541-330GCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.1W, Value_Code=330R, ValueDisplayed=330
R118: library part CMP-0023129-5, "RES, 470, 1%, 0.1 W, 0603", Manufacturer=Yageo, Power_W=100mW, Supplier Part Number 1=311-470HRCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.1W, Value_Code=470R, ValueDisplayed=470
S1: library part CMP-0097347-1, "Tactile Switch SPST-NO Top Actuated Surface Mount", Coil Resistance_ohm=100mΩ, Contact Current Rating=50mA, Digikey Part Number=732-7022-1-ND, Manufacturer="Wurth Electronics", Mouser Part Number=710-430481025816, Operating Force=160gf, Operating Temperature Range="-40°C to +85°C"
SH-J1 SH-J2 SH-J3 SH-J4 SH-J5 SH-J6 SH-J7 SH-J8 SH-J9 SH-J10 SH-J11 SH-J12 SH-J13 SH-J14 SH-J15 SH-J16 SH-J17 SH-J18 SH-J19 SH-J20 SH-J21 SH-J22 SH-J23 SH-J24 SH-J25 SH-J26 SH-J27 SH-J28 SH-J29 SH-J30 SH-J31 SH-J32 SH-J33 SH-J34 SH-J35: library part CMP-0003761-2, "Shunt, 2.54mm, Gold, Black", Manufacturer="Wurth Elektronik", Supplier Part Number 1=732-2678-ND
TP1 TP2 TP3 TP4 TP5 TP6 TP7 TP8 TP9 TP10 TP11 TP12 TP18 TP19 TP20 TP21 TP22 TP23 TP24 TP26: library part CMP-0003719-1, "Testpoint", Manufacturer="Texas Instruments"
TP25 TP29: library part CMP-0055148-2, "Test Point, Multipurpose, Black, TH", Color=Black, Manufacturer="Keystone Electronics", Supplier Part Number 1=36-5011-ND
TP27 TP28 TP30 TP36: library part CMP-0055147-2, "Test Point, Multipurpose, Red, TH", Color=Red, Manufacturer="Keystone Electronics", Supplier Part Number 1=36-5010-ND
TP31 TP32 TP34 TP35: library part CMP-0055152-2, "Test Point, Miniature, SMT", Manufacturer="Keystone Electronics", Supplier Part Number 1=36-5015TR-ND
U1: library part CMP-0038879-1, "20 MHz Mixed Signal Microcontroller with 256 KB Flash, 18432 B SRAM and 74 GPIOs, -40 to 85 degC, 100-pin QFP (PZ), Green (RoHS & no Sb/Br)", Frequency(MHz)=20, Manufacturer="Texas Instruments", Temp Sensor=Yes
U2: library part CMP-0039269-4, "16-Bit Ultra-Low-Power Microcontroller, 128KB Flash, 8KB RAM, USB, 12Bit ADC, 2 USCIs, 32Bit HW MPY, RGC0064B (VQFN-64)", Alternate Manufacturer="Texas Instruments", Alternate PartNumber=MSP430F5528IRGCR, Frequency(MHz)=25, Operating Temperature Range="-40 to 85 C", Rating=Catalog, Temp Sensor=Yes
U3: library part CMP-0036328-3, "500mA, Adjustable, Low Quiescent Current, Low-Noise, High-PSRR, Single-Output LDO Regulator, DRB0008A (VSON-8)", Manufacturer="Texas Instruments", Operating Temperature Range="-40 to 125 C", Rating=Catalog
U4: library part CMP-0004774-1, "USB to Serial UART, SSOP28", Manufacturer=FTDI, Supplier Part Number 1=768-1007-1-ND
U5: library part CMP-0090815-1, "LDO, Fixed Output, Dual, 3.3V, 10/12/15V, 50mA, Precision Enable, Power-Good, HVSSOP10", Dropout Voltage=200/800mV, Manufacturer="Texas Instruments", Max Supply Voltage=85V, Min Supply Voltage=4V, Nominal Supply Current=100uA, Operating Temperature Range="-40°C to +125°C", Output Voltage=3.3/10/12/15V
U6: library part CMP-0043099-3, "Low-Capacitance 2-Channel +/-15kV ESD Protection Array for High-Speed Data Interfaces, DRY0006A (USON-6)", Breakdown Voltage(Min)(V)=11, IO Capacitance(Typ)(pF)=1.5, IO Leakage Current(nA)=1, Manufacturer="Texas Instruments", Operating Temperature Range="-40 to 85 C", Rating=Catalog
U7: library part CMP-0094088-3, "Quad Half-Bridge Motor Driver with Current Sense Output", Manufacturer="Texas Instruments", Max Supply Voltage=60V, Min Supply Voltage=4.5V, Nominal Supply Current=3-7mA, Operating Temperature Range="-40°C to +150°C", Switching Frequency=360kHz
Y1: library part CMP-0085483-1, "Oscillator, 4 MHz, 700 ppm, 39 pF, SMD", Frequency_Fixed=4MHz, Frequency Tolerance="700 ppm", Load Capacitance="39 pF", Manufacturer=MuRata
Y2: library part CMP-0004566-4, "Crystal, 32.768 kHz, 12.5pF, SMD", Frequency Tolerance="20 ppm", Frequency_Fixed=32.768kHz, Load Capacitance="12.5 pF", Manufacturer="Micro Crystal AG", Supplier Part Number 1=94M8466
ZZ1: library part CMP-0003616-3
ZZ2: library part CMP-0077236-1
ZZ3: library part CMP-0077237-1
ZZ4: library part CMP-0077238-1

## Via types
v1: diameter 19.68, hole 13.78, Top Layer to Bottom Layer, tented both sides, 174 vias
v2: diameter 34, hole 16, Top Layer to Bottom Layer, tented both sides, 114 vias
v3: diameter 19.68, hole 7.87, Top Layer to Bottom Layer, 22 vias
v4: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 6 vias
v5: diameter 141.73, hole 141.73, Top Layer to Bottom Layer, tented both sides, 6 vias
v6: diameter 201.73, hole 141.73, Top Layer to Bottom Layer, 2 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point)
3.3V_COM: C41.1 U4.4 U4.17 | length 506.8
  Top Layer w10: U4.4@1853.79,4513.57 1926.78,4513.57 1989.62,4450.73 1989.62,4364.73 2045.51,4308.84 U4.17@2125.44,4308.84 2126.68,4310.08 2223.11,4310.08 C41.1@2224.35,4311.31
A12: A1.1 R5.2 U1.5 | length 7074.3
  Top Layer w10: U1.5@1107.48,2084.13 1107.48,2133.04 1177.04,2202.6 1177.04,2368.91 1439.72,2631.59 1651.52,2631.59 A1.1@1736.04,2716.1 ; v2(6150,3865.91) 6150,3734.84 6320.28,3564.56 R5.2@6320.28,3562.59
  Signal Layer 2 w12: A1.1@1736.04,2716.1 1736.04,2820.41 1977.36,3061.73 1977.36,3383.19 3038.07,4443.9 5684.06,4443.9 6150,3977.95 v2(6150,3865.91)
A13: A2.1 R8.2 U1.6 | length 6779.1
  Top Layer w10: U1.6@1087.8,2084.13 1087.8,2138.63 1159.17,2210 1159.17,2386.19 1482.34,2709.36 A2.1@1546.8,2709.36 ; v2(6150,4100) 6318.06,3931.94 6318.06,3870.75 R8.2@6322.91,3865.91
  Signal Layer 2 w12: A2.1@1560,2724.09 1561.54,2724.09 1957.49,3120.04 1957.49,3391.42 3029.84,4463.77 5786.23,4463.77 v2(6150,4100)
A14: A3.1 R13.2 U1.7 | length 6718.5
  Top Layer w10: U1.7@1068.11,2084.13 1068.11,2144.22 1135.23,2211.34 1135.23,2568.12 1276.47,2709.36 A3.1@1357.57,2709.36 ; v2(6150,4225) 6229.96,4145.04 R13.2@6328.91,4145.04
  Signal Layer 2 w12: A3.1@1357.57,2709.36 1357.57,2830.01 3021.65,4494.09 5880.91,4494.09 v2(6150,4225)
A15: A4.1 R16.2 U1.8 | length 6621.2
  Top Layer w10: U1.8@1048.43,2084.13 1048.43,2149.81 1101.01,2202.4 1101.01,2642.04 A4.1@1168.33,2709.36 ; v2(6150,4520) 6216.28,4453.72 R16.2@6337.15,4453.72
  Signal Layer 2 w12: A4.1@1168.33,2709.36 1175.44,2709.36 1213.25,2747.17 1242.25,2747.17 3015.08,4520 v2(6150,4520)
ACCEL/DECEL: D10.2 U1.37 | length 333.2
  Top Layer w10: D10.2@360.2,1914.51 405.68,1914.51 520.5,1799.69 U1.37@645.87,1799.69
AOUT1/OUT1: C52.2 C60.1 J14.2 J22.2 R89.2 TP31.1 U7.17 U7.18 U7.19 | length 779.8
  Top Layer w10: C52.2@6362.91,3224.28 TP31.1@6524.95,3224.28 ; J14.2@6400.73,2939.62 6524.95,3063.85 TP31.1@6524.95,3224.28 ; R89.2@6524.95,3392.64 TP31.1@6524.95,3224.28 ; TP31.1@6532.84,3228.91 6528.22,3224.28 TP31.1@6524.95,3224.28
  Bottom Layer w10: J14.2@6400.73,2939.62 6404.15,2936.2 C60.1@6404.15,2837.53
AOUT2/OUT2: C60.2 C61.2 J14.1 J24.2 R90.2 TP32.1 U7.14 U7.15 U7.16 | length 1705.2
  Top Layer w10: C61.2@6379.53,2430.84 6534.44,2430.84 TP32.1@6534.91,2431.3 6534.91,2684.62 6529.91,2689.62 ; J14.1@6400.73,2689.62 6529.91,2689.62 ; R90.2@6519.12,3679.85 6520.11,3679.85 6602.11,3597.85 6602.11,2756.83 6534.91,2689.62 6529.91,2689.62
  Bottom Layer w10: J14.1@6400.73,2689.62 6404.15,2693.05 C60.2@6404.15,2790.28
BOUT1/OUT3: C64.2 C65.1 J13.1 J22.1 R91.2 TP34.1 U7.4 U7.5 U7.6 | length 3301.3
  Top Layer w10: C64.2@6173.44,1364.38 6174.38,1364.38 6200.52,1390.52 6520.52,1390.52 TP34.1@6526.91,1396.91 ; J13.1@6400.91,1658.91 6400.91,1522.91 TP34.1@6526.91,1396.91 ; R91.2@6529.39,3969.22 6539.55,3959.05 6539.55,3945.69 6573.82,3911.42 v1(6625,3911.42) ; TP34.1@6538.91,1384.91 TP34.1@6526.91,1396.91 ; TP34.1@6538.91,1408.91 TP34.1@6526.91,1396.91
  Bottom Layer w10: C65.1@6401.91,1755.28 6401.91,1659.91 6400.91,1658.91 6400.91,1676.96 6430.32,1706.37 6458.88,1706.37 6625,1872.49 v1(6625,3911.42)
BOUT2/OUT4: C65.2 C66.2 J13.2 J24.1 R92.2 TP35.1 U7.7 U7.8 U7.9 | length 3246.6
  Top Layer w10: C66.2@6380.53,2325.91 6380.53,2267.33 6446.96,2200.91 TP35.1@6532.91,2200.91 6532.91,1984.91 6456.91,1908.91 J13.2@6400.91,1908.91 ; R92.2@6529.95,4279.35 6530.93,4279.35 6541.68,4268.6 6541.68,4267.61 6589.57,4219.73 v1(6589.57,3943.89)
  Bottom Layer w10: C65.2@6401.91,1802.53 6400.91,1803.53 6400.91,1908.91 6482.91,1908.91 6589.57,2015.57 v1(6589.57,3943.89)
C2K_3V3: J1.1 R1.2 | length 110.6
  Top Layer w10: J1.1@2991.3,143.45 2994.05,140.69 R1.2@3100.74,140.69
C2K_AOUT1: R7.2
C2K_AOUT2: R10.2
C2K_BOUT1: R12.2
C2K_BOUT2: R15.2
C2K_DECAY0/SDI/DECAY/EN1: J2.12 R26.2 | length 283.8
  Top Layer w10: J2.12@1191.3,643.45 1198.16,650.32 1236.81,650.32 1281.37,694.88 1371.8,694.88 1428.38,638.3 R26.2@1430.35,638.3
C2K_DECAY1/SDO/RSVD/EN2: J2.14 R25.2 | length 278.8
  Top Layer w10: J2.14@1191.3,743.45 1199.9,752.05 1227.05,752.05 1275.06,800.06 1365.06,800.06 1406,841 R25.2@1429.67,841
C2K_DIR/IN2/PH2: J2.5 R32.2 | length 144.9
  Top Layer w10: J2.5@1291.3,343.45 1292.28,342.46 1434.41,342.46 R32.2@1435.39,341.48
C2K_ENABLE/IN1/PH1: J1.9 R33.2 | length 107.8
  Top Layer w10: J1.9@2991.3,543.45 2991.69,543.84 3098.38,543.84 R33.2@3098.78,544.24
C2K_IPROPI1/IPROPI2: C4.1 J1.14 R18.2 TP42.1 | length 741.3
  Top Layer w10: R18.2@2627.28,731.24 2727.22,731.24 2730.97,735 2780,735 2788.45,743.45 J1.14@2891.3,743.45 2935.85,788 TP42.1@3345.04,788
C2K_IPROPI2/IPROPI3: C5.1 J1.16 R17.2 TP43.1 | length 941.6
  Top Layer w10: R17.2@2626.33,848.65 2629.99,845 2680,845 2690.26,855.26 C5.1@2728.82,855.26 2819.74,855.26 2831.55,843.45 J1.16@2891.3,843.45 2947.91,900.06 3528.31,900.06 TP43.1@3532.25,904
C2K_M0/nSCS/VREF1/EN4: J2.18 R23.2 | length 280
  Top Layer w10: J2.18@1191.3,943.45 1234.68,900.06 1378.76,900.06 1430.07,951.37 R23.2@1432.03,951.37
C2K_M1/SCLK/IN4/PH4: J1.13 R27.2 | length 109.3
  Top Layer w10: J1.13@2991.3,743.45 2993.46,741.28 3096.61,741.28 R27.2@3098.78,739.12
C2K_MODE2/IPROPI4: C6.1 J1.18 R14.2 TP44.1 | length 771.4
  Top Layer w10: R14.2@2626.33,947.78 2629.11,945 2660,945 2688.37,973.37 C6.1@2728.82,973.37 2856.85,973.37 2886.77,943.45 J1.18@2891.3,943.45 2938.8,990.95 3344.68,990.95 TP44.1@3350.39,985.24
C2K_MODE/MODE1: J2.13 R11.2 | length 144.1
  Top Layer w10: J2.13@1291.3,743.45 R11.2@1435.39,743.45
C2K_nFAULT: J1.15 R6.2 | length 108.7
  Top Layer w10: J1.15@2991.3,843.45 2992.77,844.93 3097.3,844.93 R6.2@3098.78,846.4
C2K_nHOME/OCPM: J2.1 R9.2 | length 145.3
  Top Layer w10: J2.1@1292.32,144.09 1297.69,138.72 R9.2@1435.39,138.72
C2K_nSLEEP: J2.7 R34.2 | length 145.1
  Top Layer w10: J2.7@1291.3,443.45 1292.48,444.63 1434.21,444.63 R34.2@1435.39,445.81
C2K_RSVD/IPROPI1: C3.1 J1.12 R21.2 TP41.1 | length 952
  Top Layer w10: R21.2@2626.33,615.26 2727.45,615.26 C3.1@2728.82,616.63 2730.46,615 2790,615 2818.45,643.45 J1.12@2891.3,643.45 2942.85,695 3425,695 3456,726 TP41.1@3531.16,726
C2K_STEP/IN3/PH3: J2.20 R30.2 | length 258.3
  Top Layer w10: J2.20@1191.3,1043.45 1199.53,1051.69 1238.18,1051.69 1274.69,1088.2 1428.52,1088.2 R30.2@1430.32,1090
C2K_TOFF/RSVD/EN3: J2.3 R24.2 | length 145.1
  Top Layer w10: J2.3@1299.53,238.38 R24.2@1444.59,238.38
C2K_VREF: J1.20 R19.1 TP45.1 | length 824.9
  Top Layer w10: R19.1@2763,1127 2763.99,1127 2845.78,1045.2 2889.54,1045.2 J1.20@2891.3,1043.45 2934.68,1086.83 3528.52,1086.83 TP45.1@3533.35,1082
DIR/IN2: J8.6 R32.1 U7.27 | length 6088.4
  Top Layer w10: R32.1@1474.76,341.48 1476.73,341.48 1481.57,346.32 1481.57,348.29 2480,1346.72 v2(2480,1530) ; J8.6@2600,3460 3132.53,3460 3962.75,2629.78 3962.75,2613.08 4363.33,2212.5 U7.27@4437.36,2212.5
  Bottom Layer w10: v2(2480,1530) 2480,2647.25 2935,3102.25 v2(2935,3460)
DM: R73.2 U4.16 | length 420.9
  Top Layer w10: R73.2@1741.97,4251.15 1771.12,4222 1991.85,4222 2053.1,4283.25 U4.16@2125.44,4283.25
DP: R71.2 U4.15 | length 430.4
  Top Layer w10: R71.2@1741.35,4188.18 2085.88,4188.18 2125.44,4227.74 U4.15@2125.44,4257.66
DRV_ENABLE: D9.2 U1.36 | length 403.6
  Top Layer w10: D9.2@360.24,2040.05 360.24,1994.76 535.63,1819.37 U1.36@645.87,1819.37
DVDD: C49.2 TP28.1 U7.43 | length 1346.2
  Top Layer w10: C49.2@3529.53,2547.6 3532.13,2545 TP28.1@3665.42,2545 ; v2(4180.12,1808.07) 4182.33,1810.29 4435.15,1810.29 U7.43@4437.36,1812.5
  Signal Layer 2 w15: TP28.1@3665.42,2545 3665.42,2322.77 v2(4180.12,1808.07)
EN4: D12.2 U1.40 | length 319.3
  Top Layer w10: D12.2@359.29,1661.57 412.48,1661.57 491.54,1740.63 U1.40@645.87,1740.63
ENABLE/IN1: J8.4 R33.1 U7.26 | length 4824
  Top Layer w10: J8.4@2600,3560 3058.08,3560 4110,2508.08 v2@4110,2501.4 ; R33.1@3138.15,544.24 3140.26,542.12 3247.88,542.12 v2(3250,540) ; v2(4114.04,2504.04) 4380.58,2237.5 U7.26@4437.36,2237.5
  Bottom Layer w10: v2(3250,540) 3250,1175 3465.92,1390.92 cw(c3520,1375) 3504.08,1429.08 4055,1980 4055,2445 v2(4114.04,2504.04)
EVM_STATUS: D6.2 U1.34 | length 600.8
  Top Layer w10: D6.2@359.8,2285.58 359.8,2249.34 400,2209.14 400,2094.42 420,2074.42 420,1990 551.26,1858.74 U1.34@645.87,1858.74
EZFET_AVBUS: C24.1 R56.1 R61.2 U2.1 | length 482.9
  Top Layer w6: 782.32,4577.36 783.14,4578.18 783.14,4595.46 783.14,4599.22 783.14,4643.56 R56.1@786.37,4646.78 ; C24.1@782.89,4547.39 782.32,4547.97 782.32,4578.18 782.32,4595.46 R61.2@786.08,4599.22 ; 819.67,4407.58 926.18,4301.07 U2.1@926.18,4252.1
  Top Layer w10: C24.1@782.89,4547.39 802.81,4527.48 802.81,4526.12 808.87,4526.12 819.67,4515.32 819.67,4407.58
EZFET_AVCC2ADC: C22.1 R55.1 R60.2 U2.2 | length 356.3
  Top Layer w6: C22.1@782.43,4390.81 782.43,4368.21 793.64,4356.99 793.64,4355.89 801.77,4347.76 849.89,4347.76 912.26,4285.4 912.26,4270.26 904.44,4262.44 904.44,4251.78 907.25,4248.97 907.25,4243.19 U2.2@912.26,4238.18 ; C22.1@784.6,4390.81 782.43,4392.98 R60.2@782.43,4446.4 ; R60.2@786.37,4442.46 R60.2@782.43,4446.4 ; R55.1@786.37,4491.87 782.43,4491.87 R60.2@782.43,4450.11 ; R60.2@782.43,4446.4 R60.2@782.43,4450.11 ; R60.2@782.43,4446.4 R60.2@782.43,4450.11
EZFET_D_N: C42.1 R72.2 U2.52 | length 617
  Top Layer w10: U2.52@1129.4,4085.07 1132.36,4085.07 1132.36,4090.31 1136.93,4094.89 1247.53,4094.89 1329.13,4176.49 1417.7,4176.49 C42.1@1498.87,4257.66 1498.87,4421.53 R72.2@1505.29,4427.95
EZFET_D_P: C43.1 R75.2 R76.1 R77.2 U2.50 | length 675.1
  Top Layer w10: U2.50@1157.24,4057.23 1159.8,4057.23 1159.8,4062.74 1164.12,4067.05 1268.56,4067.05 R76.1@1285.53,4084.03 1285.53,4085.59 R77.2@1314,4114.06 1314,4121.64 1391.13,4121.64 1495.59,4226.1 1530.04,4226.1 1554.42,4250.47 C43.1@1554.42,4257.66 1546.25,4265.83 1546.25,4427.25 1554.42,4427.25 R75.2@1553.72,4427.95
EZFET_LED0: R58.2 U2.20 | length 334.1
  Top Layer w10: R58.2@504.92,4149.61 504.92,4145.67 695.06,3955.53 748.93,3955.53 U2.20@754.14,3960.74
EZFET_LED1: R59.2 U2.21 | length 413.2
  Top Layer w10: R59.2@455.71,4149.61 455.71,4145.67 663.72,3937.66 758.9,3937.66 772.68,3951.44 U2.21@773.07,3951.44
EZFET_PUR: R76.2 U2.51 | length 282.9
  Top Layer w6: v1(1121.45,4048.93) 1143.32,4070.81 U2.51@1143.32,4071.34
  Top Layer w10: v1(1246.35,3984.64) 1252.95,3984.64 1294.35,4026.03 R76.2@1318.94,4050.62
  Bottom Layer w10: v1(1121.45,4048.93) 1151.9,4048.93 1216.2,3984.64 v1(1246.35,3984.64)
EZFET_RST: C23.1 J9.11 R57.1 U2.64 | length 1323.1
  Top Layer w10: C23.1@532.35,4568.4 R57.1@593.25,4568.4 596.35,4571.51 596.35,4671.64 600.35,4675.64 ; J9.11@670.78,4892.4 621.17,4842.8 510.51,4842.8 480.19,4812.48 480.19,4729.8 534.35,4675.64 596.35,4675.64 600.35,4675.64 ; U2.64@962.37,4252.1 962.37,4252.3 974.26,4264.18 974.26,4282.23 838.87,4417.62 838.87,4641.48 804.71,4675.64 600.35,4675.64
EZFET_TCK: J9.7 U2.63 | length 899.5
  Top Layer w10: J9.7@867.11,4890.24 819.67,4842.8 755.53,4842.8 721.76,4809.03 721.76,4771.46 748.32,4744.89 801.73,4744.89 856.74,4689.88 856.74,4441.39 992.13,4306 992.13,4254.22 U2.63@976.29,4238.38
EZFET_TDI: J9.3 U2.61 | length 839
  Top Layer w10: U2.61@1004.13,4210.54 1027.88,4234.29 1027.88,4321.6 921.76,4427.72 921.76,4507.82 927.62,4513.68 927.62,4575.87 921.76,4581.73 921.76,4813.85 947.16,4839.26 1016.12,4839.26 J9.3@1067.11,4890.24
EZFET_TDO: J9.1 U2.60 | length 870.4
  Top Layer w10: U2.60@1018.05,4196.62 1029.94,4208.51 1029.94,4211.06 1045.75,4226.89 1045.75,4330.6 954.63,4421.72 954.63,4708.05 953.68,4709.01 983.51,4738.84 1021.76,4777.09 1021.76,4811.01 1050,4839.26 1116.12,4839.26 J9.1@1167.11,4890.24
EZFET_TEST: J9.8 U2.59 | length 726
  Top Layer w10: J9.8@870.78,4792.4 902.35,4760.83 v1@902.35,4547 ; v1(1010.14,4157.8) 1010.14,4160.87 1031.87,4182.6 U2.59@1031.97,4182.7
  Bottom Layer w10: v1(902.96,4547) 902.96,4264.98 v1(1010.14,4157.8)
EZFET_TMS: J9.5 U2.62 | length 852.8
  Top Layer w10: J9.5@967.11,4890.24 921.12,4844.26 851.78,4844.26 821.76,4814.23 821.76,4771.46 877.27,4715.94 877.27,4446.92 1010.01,4314.19 1010.01,4244.25 U2.62@990.21,4224.46
EZFET_UARTRXD: R66.1 R70.2 U2.38 | length 1322.4
  Top Layer w10: U2.38@1031.97,3868.12 1057.02,3843.06 1057.02,3801.44 v1(1058.52,3799.94) 1058.52,3648.63 R66.1@1038.75,3628.85 ; v1@1693.86,4428.25 R70.2@1693.86,4488.9
  Bottom Layer w10: v1(1058.52,3799.94) 1175.58,3917 1356.35,3917 1694.35,4255 v1(1694.35,4434)
EZFET_UARTTXD: R67.1 R69.1 U2.37 | length 1424.8
  Top Layer w10: R67.1@938.47,3628.8 1029.94,3720.26 1029.94,3842.31 U2.37@1018.05,3854.2 ; v1(1665.88,4526) 1665.88,4560.07 1664.96,4560.98 1692.59,4588.61 R69.1@1692.59,4594
  Bottom Layer w10: v1(1030.96,3819) v1(1030.96,3819) 1160.24,3948.21 1342.41,3948.21 1665.88,4271.68 v1(1665.88,4526)
EZFET_USB_Shield: C47.1 J11.6 J11.7 J11.8 J11.9 J11.10 J11.11 R78.2 | length 817.3
  Top Layer w10: J11.10@1354.7,4906.19 J11.9@1473.3,4906.19 ; J11.11@1413.26,4815.63 1413.26,4827.94 1451.23,4865.91 1451.23,4884.12 J11.9@1473.3,4906.19 ; J11.8@1547.12,4906.19 J11.8@1547.12,4875.67 ; J11.7@1665.72,4906.19 1665.72,4886.5 1607.16,4827.94 J11.6@1607.16,4815.63 ; R78.2@1786.73,4861 1786.73,4818.53 C47.1@1786.73,4798.03 1780.63,4804.13 1618.66,4804.13 J11.6@1607.16,4815.63 ; J11.9@1473.3,4906.19 1525.05,4906.19 1547.12,4884.12 J11.8@1547.12,4875.67 ; J11.8@1547.12,4875.67 1549.01,4873.78 1569.19,4873.78 1583.12,4859.85 1583.12,4839.67 J11.6@1607.16,4815.63
EZFET_V18: C28.1 U2.55 | length 131.5
  Top Layer w10: U2.55@1087.65,4127.02 1128.65,4167.94 1128.65,4193.64 1140.35,4205.34 C28.1@1162.5,4227.49
EZFET_VBUS: C20.1 C21.1 C35.1 C36.1 C37.1 C48.1 D3.1 R56.2 U2.53 U3.5 U3.8 U4.20 U6.1 | length 3000.8
  Top Layer w10: v1(704.92,4646.78) R56.2@735.19,4646.78 ; U2.53@1115.49,4099.18 1170.78,4152.66 ; 1171.41,4152.03 1212.03,4152.03 C20.1@1225.05,4165.04 1236.05,4154.04 v1(1274.35,4154.04) ; v1(1209.61,4502.62) C35.1@1237.17,4502.62 ; C35.1@1240.16,4501.97 1241.14,4500.98 C36.1@1296.26,4500.98 ; v1(1305.31,3994) 1378.94,3920.37 C21.1@1378.94,3917.41 ; v1(2048.06,4385.61) U4.20@2125.44,4385.61
  Top Layer w12: U3.8@1366.66,4419.89 1366.56,4419.99 1366.56,4425.7 1310.8,4481.45 1310.8,4482.5 1301.09,4492.22 1301.09,4496.16 1297.7,4499.55 1299.63,4501.48 1347.93,4501.48 C37.1@1348.43,4500.99 1348.43,4504.92 1354.24,4510.73 1372,4510.73 1388.45,4527.18 1412.45,4527.18 1418.26,4532.99 1418.26,4540.87 1424.07,4546.68 1429.19,4546.68 1446.1,4563.6 v1(1448.18,4563.6) 1448.18,4565.67 1437.08,4576.78 1437.08,4661.69 1443.48,4668.09 1467.48,4668.09 U6.1@1481.29,4681.89 ; U3.8@1366.66,4425.6 1366.76,4425.7 1366.76,4430.79 1381.54,4445.57 1428.55,4445.57 1443.33,4430.79 1443.33,4419.99 U3.5@1443.43,4419.89
  Bottom Layer w10: v1(704.92,4646.78) 706.77,4644.93 719.54,4644.93 742.61,4621.86 1120.19,4621.86 1209.61,4532.44 v1(1209.61,4502.62) ; v1(1305.31,3994) 1275.22,4024.1 1271.63,4024.1 1271.63,4151.32 v1(1274.35,4154.04) 1316.75,4196.44 1316.75,4266.08 1262.24,4320.59 1262.24,4380.41 1445.43,4563.6 v1(1448.18,4563.6) 1448.18,4563.5 1462.89,4548.79 1848.68,4548.79 2008.74,4388.73 v1@2047.62,4388.73
EZFET_VCC: C31.1 C32.1 C33.1 C34.1 J10.9 R55.2 R57.2 R62.1 R63.1 R68.2 R74.2 U2.11 U2.15 U2.40 | length 3040
  Top Layer w10: C31.1@664.94,4152.31 747.78,4152.31 ; v1@690.83,4104.97 692.68,4103.12 692.68,4095.85 U2.15@726.49,4062.04 ; U2.11@782.27,4117.82 747.78,4152.31 ; C32.1@792.96,4242.63 792.96,4238.7 786.15,4231.89 755.73,4231.89 740.58,4216.73 740.58,4199.2 v1(738.72,4197.35) 740.58,4195.49 740.58,4172.87 747.78,4165.67 747.78,4152.31 ; U2.40@1059.81,3895.96 1077.09,3878.67 1101.33,3878.67 1130,3850 1131.95,3850 v1(1150.21,3831.74) 1150.21,3781.99 C34.1@1138.67,3770.46
  Top Layer w15: R57.2@593.25,4521.16 596.78,4521.16 597.56,4520.38 675.96,4520.38 704.47,4491.87 R55.2@735.19,4491.87 ; C31.1@661.3,4148.66 669.18,4148.66 689.23,4128.6 689.23,4108.22 690.83,4106.62 v1(690.83,4105.36) ; v1(977.35,4583) 978.25,4582.1 1103.16,4582.1 1105.5,4579.76 R62.1@1105.5,4579.53 R63.1@1146.88,4579.53
  Top Layer w20: v1(1470.63,3973.24) R74.2@1470.63,4019.83 1471.46,4020.66 1471.46,4054.01 1483.18,4065.73 1506.69,4065.73 1506.85,4065.88 R68.2@1506.85,4066.36
  Bottom Layer w14: v1(705.26,4491.87) 748.96,4491.87 ; v1(738.72,4197.35) 738.72,4340.26 748.96,4350.5 748.96,4491.87 ; v1(977.35,4583) 840.09,4583 748.96,4491.87
  Bottom Layer w20: v1(690.83,4105.36) 699.64,4105.36 1090.47,3714.53 ; J10.9@896.35,3460.02 904.95,3468.62 904.95,3529.01 1090.47,3714.53 ; v1(1470.63,3973.24) 1391.52,3894.13 1212.59,3894.13 v1(1150.21,3831.74) 1146.56,3828.09 1146.56,3770.61 1090.47,3714.53
EZFET_VCORE: C29.1 U2.17 | length 213.9
  Top Layer w10: C29.1@572.75,4151.42 578.82,4145.35 578.82,4128.72 633.5,4074.04 650.66,4074.04 U2.17@717.29,4007.41
EZFET_VREF: C25.1 U2.9 | length 138.9
  Top Layer w10: 797.99,4185.47 797.99,4157.77 U2.9@814.83,4140.94 ; 797.99,4185.47 836.32,4223.79 836.32,4248.51 C25.1@842.35,4254.54
EZFET_VUSB: C30.1 U2.54 | length 124
  Top Layer w10: U2.54@1101.57,4113.1 1149.42,4160.87 C30.1@1190.02,4199.93
EZFET_XT2IN: U2.57 Y1.1 | length 201.2
  Top Layer w10: U2.57@1059.81,4154.86 1085.37,4180.43 1085.37,4256.4 Y1.1@1148.37,4319.39
EZFET_XT2OUT: U2.58 Y1.3 | length 234
  Top Layer w10: U2.58@1045.89,4168.78 1065.04,4187.93 1065.04,4343.67 1053.88,4354.83 Y1.3@1053.88,4390.26