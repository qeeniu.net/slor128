# Altium PCB MD040_RevA.PcbDoc (part 5 of 5)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 5000 x 5000 mil, 4 copper layers (Top Layer, Signal Layer 1, Signal Layer 2, Bottom Layer), stack 61.2 mil thick; 336 components, 205 nets, 921 pads, 354 vias.
Unrouted connection lines stored in the file: 124.

## Via types
v1: diameter 19.68, hole 13.78, Top Layer to Bottom Layer, tented both sides, 232 vias
v2: diameter 19.68, hole 7.87, Top Layer to Bottom Layer, 87 vias
v3: diameter 19.68, hole 13.78, Top Layer to Bottom Layer, tented bottom, 31 vias
v4: diameter 141.73, hole 141.73, Top Layer to Bottom Layer, tented both sides, 4 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
VREF/VREF2: J5.1 J6.1 J7.1 J25.2 U7.33 | length 1954.6
  Top Layer w10: J25.2@2472.62,2753 J6.1@2301,2753 J7.1@2301,2613.02 2301,2606.65 2760.7,2606.65 2824.18,2670.13 2824.18,2703.43 J5.1@2874,2753.25 2930.74,2696.51 2930.74,2608.09 2977.52,2561.31 3425.6,2561.31 3450.12,2585.83 U7.33@3715.97,2585.83
VSEN_AOUT1: C67.1 R5.1 R7.1 R89.1 R93.2 | length 202.5
  Top Layer w10: R5.1@4663,1490.68 R7.1@4705,1490.68 4706.9,1488.79 4756.1,1488.79 C67.1@4758,1486.89 ; C67.1@4760,1486.89 4790.23,1486.89 R93.2@4803.22,1499.87 ; R93.2@4817,1499.05 R89.1@4817,1556.34
VSEN_AOUT2: C68.1 R8.1 R10.1 R90.1 R94.2 | length 312.7
  Top Layer w10: R8.1@4652,1175.68 R10.1@4696,1175.68 4697.9,1173.79 4748.1,1173.79 4750,1171.89 4750,1171.68 4756,1171.68 R94.2@4798.47,1171.68 ; R90.1@4808.22,1270.93 4808.22,1183.28 R94.2@4809.14,1182.35 ; R94.2@4798.47,1171.68 R94.2@4809.14,1182.35 ; R94.2@4798.47,1171.68 R94.2@4809.14,1182.35 ; R94.2@4798.47,1171.68 R94.2@4809.14,1182.35 ; R94.2@4798.47,1171.68 R94.2@4809.14,1182.35 ; R94.2@4798.47,1171.68 R94.2@4809.14,1182.35
VSEN_BOUT1: C69.1 R12.1 R13.1 R91.1 R95.2 | length 233.4
  Top Layer w10: R13.1@4665,901.86 R12.1@4704,901.86 4705.9,899.96 4754.1,899.96 4756,898.07 4756,899.89 4764.84,908.74 R95.2@4818.48,908.74 R91.1@4818.48,981.57
VSEN_BOUT2: C70.1 R15.1 R16.1 R92.1 R96.2 | length 224.8
  Top Layer w10: R16.1@4665,597.68 R15.1@4704,597.68 4705.9,595.79 4755.1,595.79 4757,593.89 4807.33,593.89 R96.2@4818,604.56 ; R96.2@4819.04,605.6 R92.1@4819.04,671.44
VSEN_VM: C71.1 J1.3 R98.1 R104.2 TP37.1 U1.1 | length 4653.9
  Top Layer w10: U1.1@623.91,2179.12 660.88,2179.12 996,1844 v1(996,1826)
  Top Layer w15: J1.3@2966.94,218.45 3122.64,218.45 3196.69,292.5 3461.94,292.5 TP37.1@3510.44,341 3529.92,341 3565.65,305.27 4277.12,305.27 4291.59,319.74 R104.2@4325.24,319.74 4325.12,319.86 4325.12,377.9 R98.1@4325,378.02
  Bottom Layer w15: v1(996,1826) 2553,269 2916.39,269 J1.3@2966.94,218.45
pads on no net: D4.1 FID1.1 FID2.1 FID3.1 H1.0 H2.0 H3.0 H4.0 J1.2 J1.5 J1.7 J1.11 J1.17 J1.19 J2.6 J2.8 J2.9 J2.10 J2.11 J2.15 J2.16 J2.17 J2.19 J3.6 J3.10 J3.12 J3.13 J3.14 J9.6 J9.10 J9.12 J9.13 J9.14 J10.11 J10.12 J11.4 LBL1.0 Q1.3 S1.2 SH-J1.0 SH-J2.0 SH-J3.0 SH-J4.0 SH-J5.0 SH-J6.0 SH-J7.0 SH-J8.0 SH-J9.0 SH-J10.0 SH-J11.0 SH-J12.0 SH-J13.0 SH-J14.0 SH-J15.0 SH-J16.0 SH-J17.0 SH-J18.0 SH-J19.0 SH-J20.0 SH-J21.0 SH-J22.0 SH-J23.0 SH-J24.0 SH-J25.0 SH-J26.0 SH-J27.0 SH-J28.0 SH-J29.0 SH-J30.0 SH-J31.0 U1.28 U1.30 U1.47 U1.48 U1.49 U1.77 U1.78 U1.79 U1.80 U1.81 U1.82 U1.86 U2.3 U2.4 U2.5 U2.6 U2.7 U2.8 U2.10 U2.12 U2.13 U2.18 U2.19 U2.22 U2.23 U2.24 U2.25 U2.26 U2.27 U2.28 U2.29 U2.30 U2.31 U2.32 U2.33 U2.34 U2.35 U2.36 U2.41 U2.42 U2.45 U2.46 U2.47 U2.48 U3.2 U3.6 U3.7 U4.2 U4.3 U4.6 U4.8 U4.9 U4.10 U4.11 U4.12 U4.13 U4.14 U4.19 U4.22 U4.23 U4.24 U4.27 U4.28 U5.3 U5.6 U5.9 U6.5
copper on no net: | length 165.8
  Top Layer w10: 2943.44,4627.5 2968.55,4602.39 3030.06,4602.39
  Signal Layer 2 w10: 2711,2443 2776,2443 2778,2445 ; 2784,1844 2784,1845
  other v4: 255.91,255.91 4744.09,255.91 255.91,4744.09 4744.09,4744.09

## Polygon pours and split planes (outlines as drawn)
GND on Signal Layer 2 "SIGNAL_LAYER_2_GND_P199" (solid, pour order 199): 0,0 5000,0 5000,5000 0,5000
EZFET_VBUS on Signal Layer 2 "SIGNAL_LAYER_2_EZFET_VBUS_P136" (solid, remove dead copper, pour order 136): 1194.67,4999.65 1819.38,4999.65 1819.38,4455.6 1196.05,4455.6
GND on Bottom Layer "BOTTOM_LAYER_GND_P258" (solid, remove dead copper, pour order 258): 0,0 5000,0 5000,5000 0,5000
EZFET_USB_Shield on Bottom Layer "BOTTOM_LAYER_EZFET_USB_SHIELD_P219" (solid, remove dead copper, pour order 219): 935.19,4018.09 1411.26,4018.09 1411.26,3810.22 935.19,3810.22
GND on Top Layer "TOP_LAYER_GND_P237" (solid, remove dead copper, pour order 237): 0,0 5000,0 5000,5000 0,5000
BOUT1/OUT3 on Top Layer "TOP_LAYER_BOUT1/OUT3_P240" (solid, pour order 240): 3995,2703 4227.21,2703 4343,2819 4343,3013 4633.89,3073 4995.69,3073 4995.69,3459.44 4994.26,3458 4351,3458 4169,3276 4169,2847 4080,2769 3995,2769
AOUT2/OUT2 on Top Layer "Top Layer-AOUT2" (solid, pour order 248): 3995,2518.76 4269.7,2519 4348.92,2598.22 4664,2598.22 4705.78,2640 4985.52,2640 4986,2639.52 4986,2241 4632.31,2241 4603.31,2270 4480,2250 4284.18,2454 3995,2454
AOUT1/OUT1 on Top Layer "Top Layer-AOUT1" (solid, pour order 250): 3994,2444 4233,2444 4415,2262 4598,2262 4629,2231 4986,2231 4986,1824.28 4984.72,1823 4385.74,1823 4201.16,2007.59 4201.16,2335.84 4158,2379 4157,2378 3994,2378
VM on Top Layer "TOP_LAYER_VM_P244" (solid, pour order 244): 3995,2593.3 3996.38,2594.69 4186,2594.69 4186,2553 3995,2553
BOUT2/OUT4 on Top Layer "TOP_LAYER_BOUT2/OUT4_P242" (solid, pour order 242): 3995,2694 4235.93,2694 4350,2808.07 4350,2966 4386,3002 4600,3002 4662,3064 4986,3064 4980,3058 4980,2650 4694,2650 4658.61,2614.61 4295.39,2614.61 4282,2628 3995,2628
VM on Top Layer "TOP_LAYER_VM_P239" (solid, pour order 239): 2082.68,1854.33 2208.66,1854.33 2208.66,1720.47
EZFET_USB_Shield on Top Layer "TOP_LAYER_EZFET_USB_SHIELD_P201" (solid, remove dead copper, pour order 201): 933.38,4018.09 1409.45,4018.09 1409.45,3810.22 933.38,3810.22
GND on Signal Layer 1 "SIGNAL_LAYER_1_GND_P184" (solid, pour order 184): 0,5000 5000,5000 5000,2805 5000,931 5000,0 1555.12,0 -12.02,0

## Keep-outs
Keep-Out Layer:
  circle w10: c4744.09,255.91 r118.11
  circle w10: c255.91,255.91 r118.11
  circle w10: c4744.09,4744.09 r118.11
  circle w10: c255.91,4744.09 r118.11
  text ".Layer_Name" at 577,-858.49 h60

## Other copper
Top Layer:
  region net VM: 3126,4702 3126,4515 3604.16,4095 3604.16,3720.25 3559.16,3675.25 3233.16,3675.25 3069.16,3849.75 3069.16,4702
  region net AOUT1/OUT1: 3981,2444 3982,2445 4262.75,2444 4476.36,2230.39 4489,2230.39 4955,2230.39 4955,2215 4954,2214 4954,1907 4935,1888 4509,1888 4211,2186 4211,2216 4196.61,2230.39 4196.61,2348.39 4179.58,2360.83 4102.17,2360.83 4084,2379 3980,2379 3979,2380 3979,2446
  region net EZFET_USB_Shield: 1273,4974.2 1273,4970.75 1273,4751 1414.31,4751 1414.31,4819.9 1431,4833 1436.89,4833 1539.58,4833 1554.1,4818.48 1554.1,4809.7 1554.1,4756.31 1559.31,4756.31 1609.51,4756.31 1609.51,4757.8 1609.51,4810.64 1678.22,4810.64 1706,4838.42 1705,4973.75 1697.61,4973.75
  region net BOUT1/OUT3: 3984,2704 3984,2768 3985,2767 4047,2768 4060,2787 4170,2787 4183.16,2800.16 4183.16,3224 4671.17,3712 4964,3715 4967,3712 4967,3178 4931,3178 4522,3178 4491.75,3147.75 4491.75,2938.75 4451.05,2887 4427.5,2857 4306.6,2703 3982,2703 3981,2704
  region net BOUT2/OUT4: 3985.66,2629 3985.66,2693 4316,2693 4506.72,2940.72 4505.54,3147.46 4524,3163 4964,3163 4967,3166 4967,2697 4762.24,2696.76 4711.74,2646.26 4655,2646.26 4655,2713.46 4598.76,2713.46 4600,2612 4578,2588 4277,2588 4277,2605 4274,2605 4251,2628 3986.08,2628 3985,2626.92
  region net AOUT2/OUT2: 3984,2518 3983,2517 3983,2454 4324,2454 4480,2250 4963,2250 4966,2247 4966,2679 4789,2679 4715,2605 4656,2605 4656,2549 4646.96,2539.96 4628,2539.96 4596.04,2539.96 4576,2560 4276,2560 4276,2534 4260,2518 3985,2518 3984,2519
  region net VM: 3983,2818.22 4040,2818 4056,2834 4056,2858 4066,2868 4157.19,2868 4159.51,2868.21 4165.11,2862.6 4165.11,2798 4050,2798 4045,2803 3983,2803
  region net VM: 3983,2594 3983.69,2594.69 4186,2594.69 4186,2553 3983,2553
  region net VM: 4049,2252.72 4058.79,2242.92 4058.79,2181.43 4183,2181.43 4183,2277.42 4130.58,2277.42 4064,2344 4002,2344 4002,2328 4045,2328 4049,2324
  text ".Layer_Name" at 577,-858.49 h60
Signal Layer 2:
  region net VM: 3048,4704 3128,4704 3128,4513.21 4249.02,3520.43 4249.02,2190.45 4022.55,2190.45 3981,2232 3981,2902 3950,2933 3950,2937 3048,3839
Bottom Layer:
  region net EZFET_USB_Shield: 1264,4974.88 1264,4797.17 1293.77,4767.4 1735.42,4767.4 1771,4802.99 1771,4974.88 1265.18,4974.88 1264.31,4974
  region net GND: 3701,2975 3995,2975 3997,2977 3997,2870 3987,2860 3975.68,2860 3969.19,2853.5 3972.07,2280.19 3986.08,2268 3985.17,2267.09 3985.17,2187 3734.36,2187 3734.36,2280.19 3750,2295.84 3750,2316.16 3750,2862 3728,2862 3700,2890 3700,2978
  text ".Layer_Name" at 577,-858.49 h60

## Silkscreen, mask and mechanical layers (free items; w line width, h text height)
Top Overlay:
  circle w19.68: c1339.15,3161.24 r5.85
  circle w19.68: c1348.15,3475 r5.85
  circle w19.68: c1225,4909 r5.85
  lines w6: 106.73,2694.31 106.73,2602.35 323.42,2372.59 ; 176,845 884.49,845 ; 177,628 889,628 ; 279.46,400 279.46,1053 ; 405,401 405,1053 ; 532,400 532,1053 ; 656,402 656,1053 ; 776,400 776,1048
  lines w7.87: 942,1457 942.97,66.22 943,7 ; 1246.94,1663.37 3194.37,1664.4 3205,2
  lines w10: 1197.29,4919.39 495.43,4919.39 495.43,4717.89 1197.29,4717.89 1197.29,4919.39 ; 1197.29,4919.39 1096.43,4919.39 1096.43,4818.64 1197.29,4818.64 1197.29,4919.39 ; 1313.86,3173.24 1213,3173.24 1213,3072.49 1313.86,3072.49 1313.86,3173.24 ; 1313.86,3173.24 612,3173.24 612,2971.74 1313.86,2971.74 1313.86,3173.24 ; 1322.86,3487 621,3487 621,3285.5 1322.86,3285.5 1322.86,3487 ; 1322.86,3487 1222,3487 1222,3386.25 1322.86,3386.25 1322.86,3487 ; 176,400 888,400 888,1053 176,1053 176,400
  text "For EZFET-LITE Flashing Only" at 602,4935 h39.37
  text "GND" at 2710,4879 h70
  text "" at 3159.45,4862.2 h60
  text "VIN" at 3308,4854 h60
  text "GND" at 4378,4852 h60
  text "VIN" at 3116,4584 h60
  text "VM" at 4716,4291 h60
  text "1" at 870,4247.8 h23.62
  text "'.PRJ_Number'.PCB_Rev" at 2389,4127 h108.27
  text "VM" at 3124.69,3828.59 h60
  text "GND" at 234,3656 h70 r90
  text "nFAULT" at 2699,3584.48 h60
  text "3V3" at 1600,3552 h70
  text "BOUT1" at 4770,3512 h60 r90
  text "OUT3" at 4929,3509 h60 r90
  text "nHOME/OCPM" at 2699,3488 h39.37
  text "MODE/MODE1" at 2699,3381 h39.37
  text "MODE2/IPROPI4" at 2698,3285.22 h39.37
  text "DVDD" at 3221,3203 h70
  text "RSVD/IPROPI3/ / IPROPI2/IPROPI" at 2705,3180.56 h39.37
  text "VM" at 4025.75,3079.2 h39.37
  text "RSVD/IPROPI2/ / IPROPI1/IPROPI" at 2699,3068 h39.37
  text "RSVD/IPROPI1" at 2700.68,2967 h39.37
  text "M0/nSCS/" at 2703,2893 h39.37
  text "VREF1/EN4" at 2703,2855.71 h39.37
  text "OUT4" at 4929,2724 h60 r90
  text "Torque Count" at 119.67,2714.71 h40 r90
  text "BOUT2" at 4753,2712 h60 r90
  text "ID4" at 1229,2612 h60
  text "ID5" at 1121,2610 h60
  text "RST" at 1569,2514 h40
  text "PUSH" at 1837,2512 h40
  text "AOUT2" at 4756,2487 h60 r90
  text "OUT2" at 4929,2484 h60 r90
  text "RSVD/TOFF/EN3" at 2698.12,2424 h60
  text "SDO/DECAY1/EN2/RSVD" at 2702,2328 h60
  text "SDI/DECAY0/EN1/DECAY" at 2702,2224 h60
  text "." at 560.25,2202.74 h60
  text "SCLK/M1/IN4/RSVD" at 2706.79,2130 h60
  text "STEP/IN3/RSVD" at 2706.79,2028 h60
  text "DIR/IN2" at 2706.79,1924 h60
  text "ENABLE/IN1" at 2707.15,1834 h60
  text "nSLEEP" at 2706,1727 h60
  text "AOUT1" at 4751,1693 h60 r90
  text "OUT1" at 4929,1691 h60 r90
  text "ID3" at 273.27,1492.19 h60
  text "C2000 connector" at 1689,1491 h108.27
  text "ID2" at 273,1404 h60
  text "GND" at 4497,1383 h70 r90
  text "LAUNCHXL-F280025C" at 1605,1326.92 h108.27
  text "ID1" at 273.27,1323.55 h60
  text "GND" at 99,955 h72.83 r90
  text "DRV89x2" at 150,859.99 h45 r90
  text "MCU_STATUS" at 235,859.99 h30 r90
  text "GUI_STATUS" at 347,859.99 h30 r90
  text "EN1" at 479.31,859.99 h40 r90
  text "EN2" at 605.4,859.99 h40 r90
  text "EN3" at 729.02,859.99 h40 r90
  text "EN4" at 856.4,859.99 h40 r90
  text "DRV82x2" at 150,647.55 h45 r90
  text "MCU_STATUS" at 236,647.55 h30 r90
  text "GUI_STATUS" at 349,647.55 h30 r90
  text "SINGLE" at 478,647.55 h40 r90
  text "DUAL" at 608.29,647.55 h40 r90
  text "NA" at 729.02,647.55 h40 r90
  text "NA" at 850.02,647.55 h40 r90
  text "DRV84x2" at 150,423 h45 r90
  text "MCU_STATUS" at 236,413 h30 r90
  text "GUI_STATUS" at 349,413 h30 r90
  text "DRV_ENABLE" at 479,413 h30 r90
  text "ACCEL/DECEL" at 612.95,413 h30 r90
  text "INDEXER HOME" at 732.32,413 h30 r90
  text "NA" at 853,413 h40 r90
  text "GND" at 948,76 h72.83
  text "3V3" at 3066,35 h72.83
  text ".Layer_Name" at 577,-858.49 h60
Bottom Overlay:
  text ".Layer_Name" at 577,-858.49 h60
Top Paste:
  text ".Layer_Name" at 577,-858.49 h60
Bottom Paste:
  text ".Layer_Name" at 577,-858.49 h60
Top Solder:
  text ".Layer_Name" at 577,-858.49 h60
  text ".Layer_Name" at 577,-858.49 h60
Bottom Solder:
  text ".Layer_Name" at 577,-858.49 h60
Drill Guide:
  text ".Layer_Name" at 577,-858.49 h60
M1 Board Outline:
  circle w10: c4744.09,4744.09 r70.87
  circle w10: c4744.09,255.91 r70.87
  circle w10: c255.91,-255.91 r70.87
  circle w10: c255.91,4744.09 r70.87
  lines w10: 0,0 0,5000 5000,5000 5000,0 0,0
  text ".Layer_Name" at 577,-858.49 h60
M2 Board Dimensions:
  rectangle: 0,-275 125,-150
  rectangle: 125,-400 500,-275
  lines w7: 0,-275 1000,-275 ; 125,-400 125,-150 ; 250,-400 250,-150 ; 500,-400 500,-150 ; 750,-400 750,-150 ; 0,-400 1000,-400 1000,-150 0,-150 0,-400
  text ".Layer_Name" at 577,-858.49 h60
M3 3D STEP Top:
  text ".Layer_Name" at 577,-858.49 h60
M4 3D STEP Bottom:
  text ".Layer_Name" at 577,-858.49 h60
M5 Assembly Top:
  lines w10: -292,-930.17 6308,-930.17 ; -292,-726.83 6310,-726.83 ; -292,-523.5 -292,-1133.5 3713,-1133.5 6310,-1133.5 6310,-523.5 -291.5,-523.5 -291.5,-1133.5 1284,-1133.5 ; 2173,-1133.5 2173,-523.5 ; 3440,-726.83 3440,-523.5 ; 4280,-726.83 4280,-523.5 ; 4902,-1140 4902,-937.17
  text "COMPONENTS MARKED 'DNP' SHOULD NOT BE POPULATED." at 1153.5,-318.5 h60
  text "ASSEMBLY VARIANT:" at 1153,-434 h60
  text ".VariantName" at 2189,-434 h60
  text "PCB VIEWED FROM TOP SIDE" at -228.5,-655.67 h60
  text "BOARD #:" at 2248,-655.67 h60
  text ".PRJ_Number" at 2793.5,-655.67 h60
  text "REV:" at 3638,-655.67 h60
  text ".PCB_Rev" at 3929.5,-655.67 h60
  text "SVN REV:" at 4476,-655.67 h60
  text ".VersionControl_RevNumber" at 4982,-655.67 h60
  text "TID #:" at 2248,-859 h60
  text ".TID" at 2793.5,-859 h60
  text "PLOT NAME =" at -228.5,-1064.34 h60
  text ".plot_File_Name" at 577,-1064.34 h60
  text "GENERATED    :" at 2250,-1064.34 h60
  text ".Print_Date" at 3119.5,-1064.34 h60
  text ".Print_Time" at 3848.5,-1064.34 h60
  text "TEXAS INSTRUMENTS" at 5113,-1064.34 h60
M6 Assembly Bottom:
  lines w10: -292.5,-727.33 6309.5,-727.33 ; -290.5,-930.67 6309.5,-930.67 ; 1115.5,-1140.5 1115.5,-937.67 ; 1737.5,-727.33 1737.5,-524 ; 2577.5,-727.33 2577.5,-524 ; 3844.5,-1134 3844.5,-524 ; 4733.5,-1134 6309,-1134 6309,-524 -292.5,-524 -292.5,-1134 2304.5,-1134 6309.5,-1134 6309.5,-524
  text "COMPONENTS MARKED 'DNP' SHOULD NOT BE POPULATED." at 6102,-318 h60
  text ".VariantName" at 5058,-434 h60
  text "ASSEMBLY VARIANT:" at 6097,-434 h60
  text ".VersionControl_RevNumber" at 1035.5,-656.17 h60
  text "SVN REV:" at 1541.5,-656.17 h60
  text ".PCB_Rev" at 2088,-656.17 h60
  text "REV:" at 2379.5,-656.17 h60
  text ".PRJ_Number" at 3224,-656.17 h60
  text "BOARD #:" at 3769.5,-656.17 h60
  text "PCB VIEWED FROM BOTTOM SIDE" at 6246,-656.17 h60
  text ".TID" at 3224,-859.5 h60
  text "TID #:" at 3769.5,-859.5 h60
  text "TEXAS INSTRUMENTS" at 904.5,-1064.84 h60
  text ".Print_Time" at 2169,-1064.84 h60
  text ".Print_Date" at 2898,-1064.84 h60
  text "GENERATED    :" at 3767.5,-1064.84 h60
  text ".plot_File_Name" at 5440.5,-1064.84 h60
  text "PLOT NAME =" at 6246,-1064.84 h60
M9 Title Sheet:
  drawing of 57 lines, arcs and shapes, not listed
  text "1" at 739.84,8036.5 h70
  text "2" at 3235.5,8036.5 h70
  text "3" at 5724.84,8036.5 h70
  text "4" at 8231.51,8036.5 h70
  text "5" at 10730.5,8036.5 h70
  text "6" at 13235.5,8036.5 h70
  text "A" at -416.5,6893.5 h70
  text "A" at 14383.5,6893.5 h70
  text "B" at -416.5,4513.5 h70
  text "B" at 14383.5,4513.5 h70
  text "C" at -416.5,2138.5 h70
  text "C" at 14383.5,2138.5 h70
  text "PROJECT TITLE:" at 11343.5,277.5 h45
  text ".PRJ_Title" at 11393.5,144.17 h70
  text "DESIGNED FOR:" at 11343.5,-23.5 h45
  text ".PRJ_Customer" at 11393.5,-163.5 h70
  text "D" at -416.5,-231.5 h70
  text "D" at 14383.5,-231.5 h70
  text "FILE NAME:" at 11343.5,-323.5 h45
  text ".PCB_File_Name_No_Path" at 11393.5,-443.5 h70
  text "Texas Instruments (TI) and/or its licensors do not warrant the accuracy or completeness of this specification" at 6374,-605.34 h45
  text "ENGINEER:" at 11343.5,-613.5 h45
  text "LAYOUT BY:" at 12848.5,-613.5 h45
  text "or any information contained therein. TI and/or its licensors do not warrant that this design will meet" at 6329.01,-718 h45
  text ".PRJ_Engineer" at 11393.5,-768.49 h70
  text ".PCB_Layout" at 12899,-768.49 h70
  text "the specifications, will be suitable for your application or fit for any particular purpose, or will operate in" at 6329.01,-830.67 h45
  text ".Layer_Name" at 577,-858.49 h60
  text "ALTIUM DESIGNER VERSION:" at 12848.5,-923.5 h45
  text "an implementation. TI and/or its licensors do not warrant that the design is production worthy. You should" at 6329.01,-943.33 h45
  text "completely validate and test your design implementation to confirm the system functionality for your application." at 6374,-1056 h45
  text ".print_Scale" at 11393.5,-1056.83 h70
  text ".Application_BuildNumber" at 12899,-1056.83 h70
  text "1" at 739.84,-1263.5 h70
  text "2" at 3235.5,-1263.5 h70
  text "3" at 5724.84,-1263.5 h70
  text "4" at 8231.51,-1263.5 h70
  text "5" at 10730.5,-1263.5 h70
  text "6" at 13235.5,-1263.5 h70
M10 Fab Notes:
  drawing of 189 lines, arcs and shapes, not listed
  text "DESIGN INFORMATION" at 12382.02,6356.17 h60
  text "MIN. TRACK WIDTH:" at 11737.46,6224.05 h60
  text "8" at 12833.7,6224.05 h60
  text "MIL" at 12988.46,6224.05 h60
  text "MIN. CLEARANCE:" at 11737.46,6099.92 h60
  text "0.2" at 12773.7,6099.93 h60
  text "mm" at 12988.46,6099.92 h60
  text "MIN. VIA PAD SIZE:" at 11737.46,5975.8 h60
  text "24" at 12803.71,5975.8 h60
  text "MIL" at 12988.46,5975.8 h60
  text "0.05mm (2MIL)" at 12432.46,5845.9 h60
  text "MINIMUM ANNULAR RING" at 11408.23,5837.67 h60
  text "EXTERNAL" at 13140.46,5837.67 h60
  text "PER" at 11608.23,5727.55 h60
  text "IPC-D-275 CLASS 2 LEVEL C" at 11828.23,5727.54 h60
  text "MIL, HOLES" at 13316.46,5627.07 h60
  text "+/-" at 12924,5618.48 h60
  text "+/-" at 13778,5618.48 h60
  text "REGISTRATION TOLERANCES:" at 11408.23,5617.42 h60
  text "METAL" at 12608,5617.42 h60
  text "5" at 13184.2,5617.42 h60
  text "3" at 14017.2,5617.42 h60
  text "MIL" at 14133.46,5617.42 h60
  text "HOLE SIZE TOLERANCE (UNLESS OTHERWISE SPECIFIED):" at 11408.23,5519.1 h60
  text "+/-" at 13778,5516.23 h60
  text "3" at 14017.2,5515.17 h60
  text "MIL" at 14133.46,5515.17 h60
  text "MATERIAL:" at 11333.46,5377.52 h60
  text "FR-4 High Tg" at 12319.9,5249 h60
  text "X" at 12175.46,5241.01 h60
  text "FR-408" at 11754.46,5236.49 h60
  text "OTHER" at 13242.46,5236.49 h60
  text "62 MIL (1.6mm) +/-10%" at 12074.56,5093.46 h60
  text "X" at 11954.46,5091.01 h60
  text "THICKNESS:" at 11408.23,5085.24 h60
  text "OTHER" at 13359.46,5085.24 h60
  text "TOLERANCE:" at 11408.23,4946.92 h60
  text "X" at 12256.46,4946.92 h60
  text "ANSI IPC-6012 TYPE 3 CLASS 2" at 12434.48,4946.92 h60
  text "OTHER +/-" at 12434.46,4802.73 h60
  text "BOW & TWIST:" at 11408.23,4657.54 h60
  text "X" at 12256.46,4657.54 h60
  text "ANSI IPC-6012 TYPE 3 CLASS 2" at 12434.48,4657.54 h60
  text "OTHER +/-" at 12434.46,4510.85 h60
  text "DRILLING:" at 11333.46,4380.23 h60
  text "NC_DRILL FILES" at 13094.46,4275.04 h60
  text "REFERENCE:" at 11408.23,4271.1 h60
  text "X" at 12065.46,4271.01 h60
  text "AS SHOWN" at 12243.46,4271.1 h60
  text "X" at 12966.46,4271.1 h60
  text "OTHER" at 13392.46,4128.85 h60
  text "PTH COPPER THICKNESS:" at 11407.91,4125.32 h60
  text "X" at 12547.14,4125.32 h60
  text "20-30 um" at 12675.14,4125.32 h60
  text "BOARD FINISH:" at 11333.46,3977.73 h60
  text "SILKSCREEN:" at 11488.68,3867.6 h60
  text "X" at 12446.46,3867.6 h60
  text "TOP" at 12563.46,3867.6 h60
  text "X" at 12956.46,3867.6 h60
  text "BOTTOM" at 13074.46,3867.6 h60
  text "SILKSCREEN COLOR:" at 11488.68,3712.41 h60
  text "X" at 12445.46,3712.41 h60
  text "WHITE" at 12563.46,3712.41 h60
  text "OTHER" at 13074.46,3712.41 h60
  text "X" at 12576.46,3568.96 h60
  text "GREEN" at 12694.46,3568.96 h60
  text "OTHER" at 13312.46,3568.96 h60
  text "SOLDER RESIST COLOR:" at 11488.68,3562.1 h60
  text "X" at 12576.46,3414.71 h60
  text "MATTE" at 12694.46,3414.71 h60
  text "SEMI-GLOSS" at 13312,3414.07 h60
  text "IMMERSION GOLD (ENIG)" at 12394.46,3241.94 h60
  text "ENEPIG" at 13732,3234.72 h60
  text "SURFACE FINISH:" at 11333.46,3233.72 h60
  text "X" at 12216.46,3233.72 h60
  text "IMM. TIN/SILVER OR EQUIV" at 11663,3096.4 h60
  text "OTHER" at 13094.46,3092.47 h60
  text "ARRAY/PANEL:" at 11333.46,2937.09 h60
  text "CUT AND TRIM PER M1 BOARD OUTLINE" at 12394.46,2928.87 h60
  text "N.C. ROUTE" at 12394.46,2792.9 h60
  text "X" at 13082.46,2792.9 h60
  text "V. SCORE" at 13260.46,2792.9 h60
  text "CERTIFICATION:" at 11333.46,2663.77 h60
  text "MATERIALS AND WORKMANSHIP FOR ALL PCBS" at 12058.46,2663.77 h60
  text "TO MEET OR EXCEED THE REQUIREMENTS OF:" at 12058.46,2569.71 h60
  text "X" at 11695.97,2441.08 h60
  text "ANSI IPC-A-600F CLASS ->" at 11823.96,2441.08 h60
  text "X" at 13471.97,2441.08 h60
  text "2" at 13581.96,2441.08 h60
  text "1" at 13266.96,2439.58 h60
  text "3" at 13935.96,2439.58 h60
  text "X" at 12507.97,2293.39 h60
  text "RoHS" at 12635.96,2293.39 h60
  text "OTHER" at 13280.36,2293.39 h60
  text "PER ORDER" at 13677.42,2293.39 h60
  text "ALL BOARDS MUST MEET OR EXCEED UL94-V0 REQUIREMENTS." at 11361,2139.57 h60
  text "PCB MUST BEAR THE UL94V-0 UL REGISTERED MATERIAL ID NUMBER" at 11361,2023.5 h60
  text "ADDITIONAL REQUIREMENTS:" at 11333.46,1854.08 h60
  text "MICROSECTION:" at 11408.23,1746.95 h60
  text "YES" at 12313.96,1746.95 h60
  text "REQUIRED" at 13175.46,1602.62 h60
  text "BARE BOARD ELEC. TEST:" at 11408.23,1599.76 h60
  text "NONE" at 12713.96,1599.76 h60
  text "X" at 13057.46,1599.76 h60
  text "PER ORDER" at 13767.46,1599.76 h60
  text "XX MIL VIAS REQUIRE NON-CONDUCTIVE FILL AND PLANARIZE" at 11576.38,1394.82 h59
  text "XX MIL VIAS REQUIRE CONDUCTIVE FILL AND PLANARIZE" at 11584.38,1290.84 h60
  text "OUTER XX MIL TRACES REQUIRE 50 OHM SINGLE-ENDED IMPEDANCE" at 11583.39,1127.46 h58
  text "LAYER 2 & 3 (INNER LAYERS) XX MIL WIDE, XX MIL SPACE / TRACES REQUIRE 100 OHM DIFFERENTIAL IMPEDANCE" at 11575.39,891.74 h60
  text ".Layer_Name" at 577,-858.49 h60
M11 Gerber Information:
  lines w10: -292,-930.17 6308,-930.17 ; -292,-726.83 6310,-726.83 ; -292,-523.5 -292,-1133.5 3713,-1133.5 6310,-1133.5 6310,-523.5 -291.5,-523.5 -291.5,-1133.5 1284,-1133.5 ; 2173,-1133.5 2173,-523.5 ; 3440,-726.83 3440,-523.5 ; 4280,-726.83 4280,-523.5 ; 4902,-1140 4902,-937.17
  text "ALL ARTWORK VIEWED FROM TOP SIDE" at -228.5,-655.67 h60
  text "BOARD #:" at 2248,-655.67 h60
  text ".PRJ_Number" at 2793.5,-655.67 h60
  text "REV:" at 3638,-655.67 h60
  text ".PCB_Rev" at 3929.5,-655.67 h60
  text "SVN REV:" at 4476,-655.67 h60
  text ".VersionControl_RevNumber" at 4982,-655.67 h60
  text "LAYER NAME =" at -228.5,-858.49 h60
  text "TID #:" at 2248,-859 h60
  text ".TID" at 2793.5,-859 h60
  text "PLOT NAME =" at -228.5,-1064.34 h60
  text ".plot_File_Name" at 577,-1064.34 h60
  text "GENERATED    :" at 2250,-1064.34 h60
  text ".Print_Date" at 3119.5,-1064.34 h60
  text ".Print_Time" at 3848.5,-1064.34 h60
  text "TEXAS INSTRUMENTS" at 5113,-1064.34 h60
M12 Stackup:
  drawing of 295 lines, arcs and shapes, not listed
  text "Layer" at 9776.35,7854 h60
  text "Name" at 10186.26,7854 h60
  text "Material" at 11126,7854 h60
  text "Thickness" at 11985.77,7854 h60
  text "Constant" at 12635.6,7854 h60
  text "Board Layer Stack" at 13205.46,7854 h60
  text "Top Overlay" at 10186.26,7734 h60
  text "Top Solder" at 10186.26,7614 h60
  text "Solder Resist" at 11126,7614 h60
  text "0.40mil" at 11985.77,7614 h60
  text "3.5" at 12635.6,7614 h60
  text "1" at 9776.35,7494 h60
  text "Top Layer" at 10186.26,7494 h60
  text "2.80mil" at 11985.77,7494 h60
  text "Dielectric 1" at 10186.26,7374 h60
  text "FR4 370" at 11126,7374 h60
  text "11.40mil" at 11985.77,7374 h60
  text "4.2" at 12635.6,7374 h60
  text "2" at 9776.35,7254 h60
  text "Signal Layer 1" at 10186.26,7254 h60
  text "1.40mil" at 11985.77,7254 h60
  text "Dielectric 2" at 10186.26,7134 h60
  text "FR4 370" at 11126,7134 h60
  text "30.00mil" at 11985.77,7134 h60
  text "4.2" at 12635.6,7134 h60
  text "3" at 9776.35,7014 h60
  text "Signal Layer 2" at 10186.26,7014 h60
  text "1.40mil" at 11985.77,7014 h60
  text "Dielectric 3" at 10186.26,6894 h60
  text "FR4 370" at 11126,6894 h60
  text "11.40mil" at 11985.77,6894 h60
  text "4.2" at 12635.6,6894 h60
  text "4" at 9776.35,6774 h60
  text "Bottom Layer" at 10186.26,6774 h60
  text "2.80mil" at 11985.77,6774 h60
  text "Bottom Solder" at 10186.26,6654 h60
  text "Solder Resist" at 11126,6654 h60
  text "0.40mil" at 11985.77,6654 h60
  text "3.5" at 12635.6,6654 h60
  text "Bottom Overlay" at 10186.26,6534 h60
  text ".Layer_Name" at 577,-858.49 h60
M13 Component Bodies Top:
  text ".Layer_Name" at 577,-858.49 h60
M14 Component Bodies Bottom:
  text ".Layer_Name" at 577,-858.49 h60
M15 Courtyards Top:
  text ".Layer_Name" at 577,-858.49 h60
M16 Courtyards Bottom:
  text ".Layer_Name" at 577,-858.49 h60
Drill Drawing:
  circle w10: c119.57,7775.84 r16.58
  circle w10: c119.57,7775.84 r27.63
  circle w10: c119.57,6905.6 r27.63
  lines w10: 91.95,6256.37 91.95,6270.18 105.76,6284 91.95,6297.81 91.95,6311.62 105.76,6311.62 119.57,6297.81 133.39,6311.62 147.2,6311.62 147.2,6297.81 133.39,6284 147.2,6270.18 147.2,6256.37 133.39,6256.37 119.57,6270.18 105.76,6256.37 91.95,6256.37 ; 91.95,6394.5 105.76,6394.5 119.57,6380.69 133.39,6394.5 147.2,6394.5 133.39,6408.32 147.2,6422.13 133.39,6422.13 119.57,6435.94 105.76,6422.13 91.95,6422.13 105.76,6408.32 91.95,6394.5 ; 91.95,6518.82 105.76,6518.82 119.57,6505.01 133.39,6518.82 147.2,6518.82 133.39,6532.64 147.2,6546.45 133.39,6546.45 119.57,6560.26 105.76,6546.45 91.95,6546.45 105.76,6532.64 91.95,6518.82 ; 91.95,6629.33 119.57,6643.14 147.2,6629.33 133.39,6656.96 147.2,6684.58 119.57,6670.77 91.95,6684.58 105.76,6656.96 91.95,6629.33 ; 91.95,6753.65 119.57,6767.46 147.2,6753.65 133.39,6781.28 147.2,6808.9 119.57,6795.09 91.95,6808.9 105.76,6781.28 91.95,6753.65 ; 91.95,7016.1 105.76,7016.1 105.76,7002.29 133.39,7002.29 133.39,7016.1 147.2,7016.1 147.2,7043.73 133.39,7043.73 133.39,7057.54 105.76,7057.54 105.76,7043.73 91.95,7043.73 91.95,7016.1 ; 91.95,7181.86 147.2,7181.86 119.57,7126.61 91.95,7181.86 ; 91.95,7306.18 147.2,7306.18 119.57,7250.93 91.95,7306.18 ; 91.95,7402.88 119.57,7375.25 147.2,7402.88 119.57,7430.5 91.95,7402.88 ; 91.95,7499.57 147.2,7499.57 147.2,7554.82 91.95,7554.82 91.95,7499.57 ; 91.95,7623.89 147.2,7623.89 147.2,7679.14 91.95,7679.14 91.95,7623.89 ; 103,6400.03 111.29,6400.03 119.57,6391.74 127.86,6400.03 136.15,6400.03 127.86,6408.32 136.15,6416.61 127.86,6416.61 119.57,6424.89 111.29,6416.61 103,6416.61 111.29,6408.32 103,6400.03 ; 103,6764.7 119.57,6772.99 136.15,6764.7 127.86,6781.28 136.15,6797.85 119.57,6789.57 103,6797.85 111.29,6781.28 103,6764.7 ; 103,7170.81 136.15,7170.81 119.57,7137.66 103,7170.81 ; 103,7510.62 136.15,7510.62 136.15,7543.77 103,7543.77 103,7510.62
  lines w12: 41.86,6219.08 3273.35,6219.08 ; 41.86,7835.24 3273.35,7835.24 ; 379.72,6094.76 379.72,7959.56 ; 711.72,6094.76 711.72,7959.56 ; 1348.28,6094.76 1348.28,7959.56 ; 1607.42,6094.76 1607.42,7959.56 ; 1982.58,6094.76 1982.58,7959.56 ; 2706.91,6094.76 2706.91,7959.56 ; 41.86,6094.76 3273.35,6094.76 3273.35,7959.56 41.86,7959.56 41.86,6094.76
  text "Symbol" at 116.45,7872.53 h72
  text "Quantity" at 417.02,7872.53 h72
  text "Finished Hole Size" at 749.02,7872.53 h72
  text "Plated" at 1385.58,7872.53 h72
  text "Hole Type" at 1644.72,7872.53 h72
  text "Drill Layer Pair" at 2019.88,7872.53 h72
  text "Hole Tolerance" at 2744.21,7872.53 h72
  text "87" at 417.02,7748.21 h60
  text "7.87mil (0.200mm)" at 749.02,7748.21 h60
  text "PTH" at 1385.58,7748.21 h60
  text "Round" at 1644.72,7748.21 h60
  text "Top Layer - Bottom Layer" at 2019.88,7748.21 h60
  text "263" at 417.02,7623.89 h60
  text "13.78mil (0.350mm)" at 749.02,7623.89 h60
  text "PTH" at 1385.58,7623.89 h60
  text "Round" at 1644.72,7623.89 h60
  text "Top Layer - Bottom Layer" at 2019.88,7623.89 h60
  text "20" at 417.02,7499.57 h60
  text "17.72mil (0.450mm)" at 749.02,7499.57 h60
  text "PTH" at 1385.58,7499.57 h60
  text "Round" at 1644.72,7499.57 h60
  text "Top Layer - Bottom Layer" at 2019.88,7499.57 h60
  text "20" at 417.02,7375.25 h60
  text "40.00mil (1.016mm)" at 749.02,7375.25 h60
  text "PTH" at 1385.58,7375.25 h60
  text "Round" at 1644.72,7375.25 h60
  text "Top Layer - Bottom Layer" at 2019.88,7375.25 h60
  text "40" at 417.02,7250.93 h60
  text "40.16mil (1.020mm)" at 749.02,7250.93 h60
  text "PTH" at 1385.58,7250.93 h60
  text "Round" at 1644.72,7250.93 h60
  text "Top Layer - Bottom Layer" at 2019.88,7250.93 h60
  text "42" at 417.02,7126.61 h60
  text "43.31mil (1.100mm)" at 749.02,7126.61 h60
  text "PTH" at 1385.58,7126.61 h60
  text "Round" at 1644.72,7126.61 h60
  text "Top Layer - Bottom Layer" at 2019.88,7126.61 h60
  text "+/-1.97mil" at 2744.21,7126.61 h60
  text "3" at 417.02,7002.29 h60
  text "45.28mil (1.150mm)" at 749.02,7002.29 h60
  text "PTH" at 1385.58,7002.29 h60
  text "Round" at 1644.72,7002.29 h60
  text "Top Layer - Bottom Layer" at 2019.88,7002.29 h60
  text "10" at 417.02,6877.97 h60
  text "51.18mil (1.300mm)" at 749.02,6877.97 h60
  text "PTH" at 1385.58,6877.97 h60
  text "Round" at 1644.72,6877.97 h60
  text "Top Layer - Bottom Layer" at 2019.88,6877.97 h60
  text "6" at 417.02,6753.65 h60
  text "59.06mil (1.500mm)" at 749.02,6753.65 h60
  text "PTH" at 1385.58,6753.65 h60
  text "Round" at 1644.72,6753.65 h60
  text "Top Layer - Bottom Layer" at 2019.88,6753.65 h60
  text "4" at 417.02,6629.33 h60
  text "62.99mil (1.600mm)" at 749.02,6629.33 h60
  text "PTH" at 1385.58,6629.33 h60
  text "Round" at 1644.72,6629.33 h60
  text "Top Layer - Bottom Layer" at 2019.88,6629.33 h60
  text "25" at 417.02,6505.01 h60
  text "63.00mil (1.600mm)" at 749.02,6505.01 h60
  text "PTH" at 1385.58,6505.01 h60
  text "Round" at 1644.72,6505.01 h60
  text "Top Layer - Bottom Layer" at 2019.88,6505.01 h60
  text "4" at 417.02,6380.69 h60
  text "141.73mil (3.600mm)" at 749.02,6380.69 h60
  text "PTH" at 1385.58,6380.69 h60
  text "Round" at 1644.72,6380.69 h60
  text "Top Layer - Bottom Layer" at 2019.88,6380.69 h60
  text "2" at 417.02,6256.37 h60
  text "23.62mil (0.600mm)" at 749.02,6256.37 h60
  text "PTH" at 1385.58,6256.37 h60
  text "Slot" at 1644.72,6256.37 h60
  text "Top Layer - Bottom Layer" at 2019.88,6256.37 h60
  text "526 Total" at 417.02,6132.05 h60
  text "Slot definitions :" at 116.45,6045.03 h60
  text "Routed Path Length" at 567.17,6045.03 h60
  text "= Calculated from tool start centre position to tool end centre position." at 1106.9,6045.03 h60
  text "Hole Length" at 567.17,5995.3 h60
  text "= Routed Path Length + Tool Size = Slot length as defined in the PCB layout" at 907.1,5995.3 h60
  text ".Layer_Name" at 577,-858.49 h60
Mechanical 17:
  text ".Layer_Name" at 577,-858.49 h60
Mechanical 18:
  text ".Layer_Name" at 577,-858.49 h60
Mechanical 19:
  text ".Layer_Name" at 577,-858.49 h60

## Dimensions
0,-94.49 to 4000,-35.43 on M1 Board Outline
0,-400 to 1000,-400 on M2 Board Dimensions
0,0 to 0,5000 on M2 Board Dimensions