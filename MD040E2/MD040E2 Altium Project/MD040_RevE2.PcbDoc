# Altium PCB MD040_RevE2.PcbDoc (part 3 of 5)
Units mm, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 127 x 127 mm, 4 copper layers (Top Layer, Signal Layer 1, Signal Layer 2, Bottom Layer), stack 1.554 mm thick; 336 components, 206 nets, 924 pads, 303 vias.
Unrouted connection lines stored in the file: 125.

## Footprints (in the part's own frame and the unit in brackets; to place one, negate y for a bottom-side part, rotate by r counter-clockwise, add the part's x,y. Pads: shape width x height; smd on the part's side, far side on the other; paste and mask are expansions set on the pad) (continued)
Wurth_61301421121 [mm] "Header, 2.54mm, 7x2, TH"
  rrect50% 1.65x1.65 hole 1.1: 1(-1.27,7.62)
  round 1.65 hole 1.1: 2(1.27,7.62) 3(-1.27,5.08) 4(1.27,5.08) 5(-1.27,2.54) 6(1.27,2.54) 7(-1.27,0) 8(1.27,0) 9(-1.27,-2.54) 10(1.27,-2.54) 11(-1.27,-5.08) 12(1.27,-5.08) 13(-1.27,-7.62) 14(1.27,-7.62)
  body extent -2.54,-8.89 2.54,8.89, height 8.55
XTAL_MS3V-T1R [mm] "Micro Crystal Switzerland recommended land pattern"
  rect 1.1x0.6 smd: 1(-2.775,0.45) 2(-2.775,-0.45)
  rect 2.4x1.5 smd: 3(2.775,0)
  silkscreen extent -1.9,-0.74 1.2,0.74, body extent -3.05,-0.74 3.65,0.74, height 1.42

## Part data
A1 A2 A3 A4 TP13 TP14 TP15 TP16 TP17 TP37 TP38 TP39 TP40 TP41 TP42 TP43 TP44 TP45 TP46: library part CMP-0055149-1, "Test Point, Multipurpose, White, TH", Color=White, Manufacturer=Keystone, Supplier Part Number 1=36-5012-ND
C1 C2 C3 C4 C5 C6 C19 C22 C24: library part CMP-0006250-2, "CAP, CERM, 33 pF, 50 V, +/- 5%, C0G/NP0, 0402", Cap_Case=0402, Manufacturer=TDK, Supplier Part Number 1=445-1241-1-ND, TempCo=C0G/NP0, Tolerance_%=5%, Value1=Unknown, Value2=50V, ValueDisplayed=33pF
C7 C8 C9 C10 C11 C12 C15 C41 C62: library part CMP-0006221-1, "CAP, CERM, 0.1 uF, 10 V, +/- 20%, X5R, 0402", Cap_Case=0402, Manufacturer="Wurth Elektronik", Supplier Part Number 1=732-7487-1-ND, TempCo=X5R, Tolerance_%=20%, Value1=Unknown, Value2=10V, ValueDisplayed=0.1uF
C13: library part CMP-0006580-1, "CAP, CERM, 0.47 uF, 10 V, +/- 10%, X5R, 0402", Cap_Case=0402, Manufacturer=MuRata, Supplier Part Number 1=490-3264-1-ND, TempCo=X5R, Tolerance_%=10%, Value1=Unknown, Value2=10V, ValueDisplayed=0.47uF
C14 C31: library part CMP-0084376-1, "CAP, Tantalum Polymer, 10 µF, 10 V,+/- 20%, 0.08 ohm, 3216-18 SMD", Cap_Case=3216-18, Manufacturer=Kemet, Tolerance_%=20%, Value1="0.08 ohm", Value2=10V, ValueDisplayed=10µF
C16 C17 C18 C21 C25 C32 C33 C34 C36 C48: library part CMP-0006562-2, "CAP, CERM, 0.1 uF, 10 V, +/- 10%, X5R, 0402", Cap_Case=0402, Manufacturer=MuRata, Supplier Part Number 1=490-1318-1-ND, TempCo=X5R, Tolerance_%=10%, Value1=Unknown, Value2=10V, ValueDisplayed=0.1uF
C20: library part CMP-0006269-2, "CAP, CERM, 4.7 uF, 10 V, +/- 20%, X5R, 0402", Cap_Case=0402, Manufacturer=TDK, Supplier Part Number 1=445-8023-1-ND, TempCo=X5R, Tolerance_%=20%, Value1=Unknown, Value2=10V, ValueDisplayed=4.7uF
C23: library part CMP-0006673-2, "CAP, CERM, 1000 pF, 50 V, +/- 10%, X7R, 0402", Cap_Case=0402, Manufacturer=MuRata, Supplier Part Number 1=490-1303-1-ND, TempCo=X7R, Tolerance_%=10%, Value1=Unknown, Value2=50V, ValueDisplayed=1000pF
C26 C27 C42 C43: library part CMP-0064916-2, "CAP, CERM, 10 pF, 50 V,+/- 1%, C0G/NP0, 0402", Cap_Case=0402, Manufacturer=MuRata, Supplier Part Number 1=490-6186-1-ND, TempCo=C0G/NP0, Tolerance_%=1%, Value1=Unknown, Value2=50V, ValueDisplayed=10pF
C28 C30 C47: library part CMP-0006570-2, "CAP, CERM, 0.22 uF, 10 V, +/- 10%, X5R, 0402", Cap_Case=0402, Manufacturer=MuRata, Supplier Part Number 1=490-3910-1-ND, TempCo=X5R, Tolerance_%=10%, Value1=Unknown, Value2=10V, ValueDisplayed=0.22uF
C29: library part CMP-0006600-2, "CAP, CERM, 0.47 uF, 16 V, +/- 10%, X5R, 0402", Cap_Case=0402, Manufacturer=MuRata, TempCo=X5R, Tolerance_%=10%, Value1=Unknown, Value2=16V, ValueDisplayed=0.47uF
C35 C40 C45: library part CMP-0064924-2, "CAP, CERM, 1 uF, 10 V,+/- 20%, X5R, 0402", Cap_Case=0402, Manufacturer="Wurth Elektronik", Supplier Part Number 1=732-7489-1-ND, TempCo=X5R, Tolerance_%=20%, Value1=Unknown, Value2=10V, ValueDisplayed=1uF
C37 C39: library part CMP-0006639-2, "CAP, CERM, 0.01 uF, 16 V, +/- 10%, X7R, 0402", Cap_Case=0402, Manufacturer=MuRata, Supplier Part Number 1=490-1313-1-ND, TempCo=X7R, Tolerance_%=10%, Value1=Unknown, Value2=16V, ValueDisplayed=0.01uF
C38: library part CMP-0006594-2, "CAP, CERM, 2.2 uF, 16 V, +/- 10%, X5R, 0402", Cap_Case=0402, Manufacturer=MuRata, PartNumber=GRM155R61C225KE11D, Supplier Part Number 1=490-10695-1-ND, TempCo=X5R, Tolerance_%=10%, Value1=Unknown, Value2=16V
C44 C50 C55: library part CMP-14477-003474-1, "Ceramic Capacitor General Use 0.1uF ±20% 100V X5R 0603", Capacitance=100nF, Case/Package=Ceramic, Dielectric=X5R, Max Operating Temperature=85°C, Min Operating Temperature=-55°C, Tolerance=20%, Voltage Rating=100V
C46: library part CMP-0008271-1, "CAP, CERM, 3.3 uF, 25 V, +/- 10%, X6S, 0805", Cap_Case=0805, Manufacturer=MuRata, Supplier Part Number 1=GRM21BC81E335KA73L-ND, TempCo=X6S, Tolerance_%=10%, Value1=Unknown, Value2=25V, ValueDisplayed=3.3uF
C49 C51: library part CMP-0007873-2, "CAP, CERM, 1 uF, 50 V, +/- 10%, X7R, 0805", Cap_Case=0805, Manufacturer=TDK, Supplier Part Number 1=445-7547-1-ND, TempCo=X7R, Tolerance_%=10%, Value1="0.008782 ohm", Value2=50V, ValueDisplayed=1uF
C52 C54 C60 C61 C64 C65 C66: library part CMP-2006-03016-2, "CAP CER 1000PF 100V X7R 0603", Capacitance="1,000 pF", Manufacturer=KEMET, Package=C0603C-CF, Temperature="-55°C to +125°C", Temperature Characteristic=X7R, Temperature Coefficient=30ppm/°C, Temperature Range High=+125°C, Temperature Range Low=-55°C, Tolerance=0.1, Voltage Rating="100 V"
C53: library part CMP-0094051-1, "100uF 100V 20% Aluminum Electrolytic Capacitors Radial, Can - SMD - 5000 Hrs @ 105°C", Digikey Part Number=565-2511-1-ND, Leakage Current=100uA, Manufacturer="United Chemi-Con", Mouser Part Number=661-EMVY101ARA101MKE, Operating Temperature Range="-40°C to +105°C", Tolerance_%=20%, ValueDisplayed=100uF
C56: library part CMP-06035-000063-1, "CAP CER 1UF 100V X7S 0805", Capacitance=1uF, Manufacturer=Murata, Package=GRM21-0.2, Temperature="-55°C to +125°C", Temperature Characteristic=X7S, Temperature Coefficient=22%, Temperature Range High=+125°C, Temperature Range Low=-55°C, Tolerance=10%, Voltage Rating=100V
C57 C58 C59: library part CMP-14477-001102-1, "Ceramic Capacitor General Use 0.01uF ±20% 100V X7R 0603", Capacitance=10nF, Case/Package=0603, Max Operating Temperature=125°C, Min Operating Temperature=-55°C, Tolerance=20%, Voltage Rating=100V
C63: library part CMP-1035-02591-1, "CAP 100nF 50V ±5% 0603 (1608 Metric) Thickness 1mm SMD", Case-EIA=0603, Case-Metric=1608, Rated Voltage="50 V", Tolerance=Â±5%
C67 C68 C69 C70 C71: library part CMP-0087080-2, "CAP CER 100PF 100V X8R 0402", Manufacturer=Kemet, TempCo=15%, Tolerance_%=5%
C72 C73: library part CMP-0006227-2, "CAP, CERM, 0.01 uF, 16 V, +/- 10%, X7R, 0402", Cap_Case=0402, Manufacturer="Wurth Elektronik", Supplier Part Number 1=710-885012205031, TempCo=X7R, Tolerance_%=10%, Value1=Unknown, Value2=16V, ValueDisplayed=0.01uF
C74: library part CMP-1036-03017-2, "CAP CER 1100PF 50V NP0 0805", Capacitance="1,100 pF", Manufacturer=KEMET, Manufacturer Part Number=C0805C112F5GACTU, Package=C0805C-DN, Temperature="-55°C to +125°C", Temperature Characteristic=C0G, Temperature Coefficient=30ppm/°C, Temperature Range High=+125°C, Temperature Range Low=-55°C, Tolerance=0.01, Voltage Rating="50 V"
D1: library part CMP-0002947-3, "LED, Red, SMD", Color=Red, Manufacturer="Wurth Elektronik", Power_TotalModule=72mW, Value1=0.072W, Value2=2V
D2: "LED, Green, SMD", Color=green, Manufacturer="Wurth Elektronik", PartNumber=150060VS75000, Value1=W, Value2=2V
D3: library part CMP-1055-00457-1, "Schottky Barrier Diode, 2-Pin SOD-323, Pb-Free, Tape and Reel", Manufacturer="On Semiconductor"
D4: library part CMP-1426-00004-1, "SMD mono-color Chip LED, WL-SMCW, Super Red", Color="Super Red", Manufacturer="Wuerth Elektronik"
D5 D6 D8: library part CMP-0002894-2, "LED, Green, SMD", Color=green, Manufacturer="Wurth Elektronik", Value1=W, Value2=2V
D7: library part CMP-0002893-1, "LED, Super Red, SMD", Color="super red", Manufacturer="Wurth Elektronik", Supplier Part Number 1=732-4979-1-ND, Value1=W, Value2=1.9V
D9 D10 D11 D12: library part CMP-0002892-3, "LED, Yellow, SMD", Color=yellow, Manufacturer="Wurth Elektronik", Value1=W, Value2=2V
D10 D11: library part CMP-0002894-2, "LED, Green, SMD"
D12: library part CMP-0002893-1, "LED, Super Red, SMD"
D13: library part CMP-14400-000003-1, "DIODE ZENER 4.7V 550MW SOD323F", Ambient Temperature Range High=+150°C, Ambient Temperature Range Low=-55°C, Forward Current=250mA, Manufacturer=Nexperia, Max Reverse Leakage Current=3uA, Max Zener Voltage=4.79V, Nom Zener Voltage=4.7V, Package=SOD323F, Power Dissipation=550mW, Reverse Voltage=2V, Temperature="to +150°C"
F1: library part CMP-0081016-1, "Fuse, 15 A, 250 VAC, 100 VDC, SMD", Irating_A=15A, Manufacturer=Littelfuse
FID1 FID2 FID3: library part CMP-0077181-1, "Fiducial mark.  There is nothing to buy or mount.", Manufacturer=N/A
H1 H2 H3 H4: library part CMP-0003678-1, "Standoff, Hex, 1.25\"L #6-32 Nylon", Manufacturer=Keystone
H1_Nut H2_Nut H3_Nut H4_Nut: library part CMP-0003948-1, "Small nylon hex nut, 0.10 thick with a 0.250 outside diameter and a 4-40 threading", Manufacturer=Keystone, Supplier Part Number 1=36-9605-ND
J1 J2: "Receptacle, 2.54mm, 10x2, Gold, TH", Color=Black, Current_A=6.3A, Manufacturer=Samtec, PartNumber=SSQ-110-03-G-D, Voltage_V=550V
J3: library part CMP-0002339-2, "Header, 100mil, 7x2, Tin, TH", Color=Black, Current_A=3A, Manufacturer="Sullins Connector Solutions", PartNumber=PEC07DAAN, Supplier Part Number 1=S2012E-07-ND, Voltage_V=1.8kV
J4 J8: library part CMP-0075595-1, "Header, 2.54mm, 8x2, Gold, SMT", Color=Black, Current_A=4.9A, Manufacturer=Samtec, Supplier Part Number 1=SAM8884-ND, Voltage_V=475V
J5 J6 J7 J16 J17 J18 J19 J20 J25 J26: library part CMP-0054566-1, "Header, 100mil, 2x1, Gold, TH", Color=Black, Current_A=3A, Manufacturer="Sullins Connector Solutions", Supplier Part Number 1=S1011E-02-ND, Voltage_V=1.8kV
J9: library part CMP-0086014-1, "Header, 2.54mm, 7x2, Gold, TH", Color=Black, Current_A=3A, Manufacturer="Wurth Elektronik", Voltage_V=250V
J10: library part CMP-0002339-2, "Header, 100mil, 7x2, Tin, TH", Color=Black, Current_A=3A, Manufacturer="Sullins Connector Solutions", Supplier Part Number 1=S2012E-07-ND, Voltage_V=1.8kV
J11: "Receptacle, USB 2.0, Micro B, 5 Position, R/A, SMT", Color=Black, Current_A=1.8A, Manufacturer=Molex, PartNumber=1051640001, Supplier Part Number 1=WM11263CT-ND, Voltage_V=30V
J12: library part CMP-0086764-1, Current_A=57A, Manufacturer=Wurth, Voltage_V=750V
J13 J14 J23: library part CMP-0093233-1, "2 Position Wire to Board Terminal Block Horizontal with Board 0.250\" (6.35mm) Through Hole", Current_A=32A, Digikey Part Number=732-691250610002-ND, Manufacturer="Wurth Electronics", Mouser Part Number=710-691250610002, Operating Temperature Range="-32°C to +120°C", Voltage_V=450V
J15 J21 J22 J24: library part CMP-0075110-1, "1mm Uninsulated Shorting Plug, 10.16mm spacing, TH", Manufacturer=Harwin, Supplier Part Number 1=952-1873-ND
J27: library part CMP-77940-000002-1, "CONN HEADER VERT 3POS 2.54MM", Current Rating=3A, Manufacturer="Metz Connect", Temperature="-40°C to +105°C", Temperature Range High=+105°C, Temperature Range Low=-40°C
L1 L2: library part CMP-0081962-1, "Ferrite Bead, 150 ohm @ 100 MHz, 0.7 A, 0603", Manufacturer=MuRata, Supplier Part Number 1=490-14035-1-ND, Value1="0.35 ohm", Value2=0.7A, ValueDisplayed="150 ohm"
LBL1: library part CMP-0003625-1, "Thermal Transfer Printable Labels, 0.650\" W x 0.200\" H - 10,000 per roll", Manufacturer=Brady, Supplier Part Number 1=97C5133
LOGO1: library part CMP-0074837-1, "IEC 61010-1 Hot Surface Warning"
Logo2: library part CMP-0074844-1
Logo3: library part CMP-0074838-1, "Texas Instrument Corporate Signature"
Logo4: library part CMP-0074847-1, "FCC_disclaimer"
Logo5: library part CMP-0074769-1
Logo6: library part CMP-0074836-1, "IEC 61010-1 Caution Warning"
Q1: library part CMP-1048-00779-1, "General Purpose Transistor, NPN Silicon, 3-Pin SOT-23, Pb-Free, Tape and Reel", Manufacturer="On Semiconductor"
R1 R5 R6 R7 R8 R9 R10 R11 R12 R13 R14 R15 R16 R17 R18 R20 R21 R22 R23 R24 R25 R26 R27 R30 R32 R33 R34 R54 R68: library part CMP-0026992-3, "RES, 0, 5%, 0.1 W, AEC-Q200 Grade 0, 0402", Manufacturer=Panasonic, PartNumber=ERJ-2GE0R00X, Power_W=100mW, Supplier Part Number 1=P0.0JCT-ND, TempCo="600 ppm/C", Tolerance_%=5%, Value2=0.1W, Value_Code=0000, ValueDisplayed=0
R2 R3: library part CMP-0025784-3, "RES, 330 k, 5%, 0.1 W, 0603", Manufacturer=Vishay-Dale, Power_W=100mW, Supplier Part Number 1=541-330KGCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.1W, Value_Code=330k
R4 R35: library part CMP-0091848-1, "10 Ohms ±5% 0.05W, 1/20W Chip Resistor 0402 (1005 Metric) RF, High Frequency Thin Film", Digikey Part Number=716-CH0402-10RJFPTCT-ND, Manufacturer=Vishay, Mouser Part Number=71-CH0402-10RJFPT, Operating Temperature Range="-55°C to +155°C", Power_W=50mW, TempCo=100ppm/°C, Tolerance_%=5%
R19 R44 R49: library part CMP-0021998-3, "RES, 10.0 k, 1%, 0.1 W, 0603", Manufacturer=Vishay-Dale, Power_W=100mW, Supplier Part Number 1=541-10.0KHCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.1W, Value_Code=10k0, ValueDisplayed=10.0k
R29: library part CMP-2002-07701-1, Manufacturer="Yageo / Phycomp", Part Number=RC0402FR-0747KL
R39 R40 R41 R42: library part CMP-0026071-2, "RES, 1.00 k, 1%, 0.063 W, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-1.00KLCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.063W, Value_Code=1k00, ValueDisplayed=1.00k
R55 R60: library part CMP-0026728-1, "RES, 220 k, 1%, 0.0625 W, 0402", Manufacturer="Yageo America", Power_W=62.5mW, Supplier Part Number 1=311-220KLRCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.0625W, Value_Code=220k
R56: library part CMP-2002-00799-3, "Chip Resistor, 240 KOhm, +/- 1%, 100 mW, -55 to 155 degC, 0402 (1005 Metric), RoHS, Tape and Reel", Case Code (Imperial)=0402, Case Code (Metric)=1005, Manufacturer="Basic Passives", Max Operating Temperature="155 degC", Min Operating Temperature="-55 degC", Package Quantity=10000, PartNumber=ERJ-2RKF2403X, Power Rating="100 mW", Resistance="240 KOhm", Tolerance=1%, Voltage Rating="50 V"
R57 R97: library part CMP-0026935-3, "RES, 47 k, 5%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-47KJCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.063W, Value_Code=47k0, ValueDisplayed=47k
R58: library part CMP-0026934-3, "RES, 470, 5%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-470JCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.063W, Value_Code=470R, ValueDisplayed=470
R59: library part CMP-0026948-3, "RES, 560, 5%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-560JCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.063W, Value_Code=560R, ValueDisplayed=560
R61: library part CMP-0026021-3, "RES, 150 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-150KLCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.063W, Value_Code=150k
R62 R63: library part CMP-0026992-3, "RES, 0, 5%, 0.1 W, AEC-Q200 Grade 0, 0402", Manufacturer=Panasonic, Power_W=100mW, Supplier Part Number 1=P0.0JCT-ND, TempCo="600 ppm/C", Tolerance_%=5%, Value2=0.1W, Value_Code=0000, ValueDisplayed=0
R64 R65 R66 R67: library part CMP-0025963-2, "RES, 10.0, 1%, 0.063 W, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-10.0LCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.063W, Value_Code=10R0, ValueDisplayed=10.0
R69 R70: library part CMP-0025697-4, "RES, 0, 5%, 0.1 W, AEC-Q200 Grade 0, 0603", Manufacturer=Vishay-Dale, PartNumber=CRCW06030000Z0EA, Power_W=100mW, Supplier Part Number 1=541-0.0GCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.1W, Value_Code=0000, ValueDisplayed=0
R71 R72 R73 R75: library part CMP-0026888-3, "RES, 27, 5%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-27JCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.063W, Value_Code=27R0, ValueDisplayed=27
R74: library part CMP-2002-00429-1, Manufacturer=Panasonic, Part Number=ERJ-2GE0R00X
R76: library part CMP-0026085-3, "RES, 1.40 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-1.40KLCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.063W, Value_Code=1k40, ValueDisplayed=1.40k
R77: library part CMP-0026859-2, "RES, 1.0 M, 5%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-1.0MJCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.063W, Value_Code=1M00, ValueDisplayed=1.0M
R78: library part CMP-0026907-3, "RES, 33 k, 5%, 0.063 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=63mW, Supplier Part Number 1=541-33KJCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.063W, Value_Code=33k0, ValueDisplayed=33k
R79 R80 R81 R82: library part CMP-0026695-1, "RES, 3.30 k, 1%, 0.1 W, AEC-Q200 Grade 0, 0402", Manufacturer=Panasonic, Power_W=100mW, Supplier Part Number 1=P3.30KLCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.1W, Value_Code=3k30, ValueDisplayed=3.30k
R83 R88: library part CMP-0025886-3, "RES, 10 k, 5%, 0.1 W, 0603", Manufacturer="Yageo America", Power_W=100mW, Supplier Part Number 1=311-10KGRCT-ND, TempCo="100 ppm/C", Tolerance_%=5%, Value2=0.1W, Value_Code=10k0, ValueDisplayed=10k
R84 R85 R86 R87: library part CMP-0081856-1, "RES, 0, 0%, 0.2 W, AEC-Q200 Grade 0, 0402", Manufacturer=Vishay-Dale, Power_W=200mW, Supplier Part Number 1=541-0.0YBTR-ND, Tolerance_%=0%, Value2=0.2W, Value_Code=0
R89 R90 R91 R92: library part CMP-0022628-3, "RES, 86.6 k, 1%, 0.1 W, 0603", Manufacturer=Vishay-Dale, Power_W=100mW, Supplier Part Number 1=541-86.6KHCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.1W, Value_Code=86k6, ValueDisplayed=86.6k
R93 R94 R95 R96 R104: library part CMP-0022458-4, "RES, 4.99 k, 1%, 0.1 W, AEC-Q200 Grade 0, 0603", Manufacturer=Vishay-Dale, Power_W=100mW, Supplier Part Number 1=541-4.99KHCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.1W, Value_Code=4k99, ValueDisplayed=4.99k
R98: library part CMP-0025663-3, "RES, 97.6 k, 0.5%, 0.1 W, 0603", Manufacturer="Yageo America", Power_W=100mW, TempCo="50 ppm/C", Tolerance_%=0.5%, Value2=0.1W, Value_Code=97k6, ValueDisplayed=97.6k
R99 R100 R101 R102 R103 R105 R106 R107 R108 R109: library part CMP-0025886-5, "RES, 10 k, 5%, 0.1 W, 0603", Manufacturer=Yageo, Power_W=100mW, Supplier Part Number 1=311-10KGRCT-ND, TempCo="100 ppm/C", Tolerance_%=5%, Value2=0.1W, Value_Code=10k0, ValueDisplayed=10k
R110: library part CMP-0023183-5, "RES, 560, 1%, 0.1 W, 0603", Manufacturer=Yageo, Power_W=100mW, Supplier Part Number 1=311-560HRCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.1W, Value_Code=560R, ValueDisplayed=560
R111 R112 R113 R114 R115 R116 R117: "RES, 330, 5%, 0.1 W, AEC-Q200 Grade 0, 0603", Manufacturer=Vishay-Dale, PartNumber=CRCW0603330RJNEA, Power_W=100mW, Supplier Part Number 1=541-330GCT-ND, TempCo="200 ppm/C", Tolerance_%=5%, Value2=0.1W, Value_Code=330R, ValueDisplayed=330
R118: library part CMP-0023129-5, "RES, 470, 1%, 0.1 W, 0603", Manufacturer=Yageo, Power_W=100mW, Supplier Part Number 1=311-470HRCT-ND, TempCo="100 ppm/C", Tolerance_%=1%, Value2=0.1W, Value_Code=470R, ValueDisplayed=470
S1: library part CMP-0002134-3, "Switch, Tactile, SPST-NO, 0.05A, 12V, SMT", CurrentRating_mA=50A, Manufacturer="TE Connectivity", Supplier Part Number 1=450-1129-ND
SH-J1 SH-J2 SH-J3 SH-J4 SH-J5 SH-J6 SH-J7 SH-J8 SH-J9 SH-J10 SH-J11 SH-J12 SH-J13 SH-J14 SH-J15 SH-J16 SH-J17 SH-J18 SH-J19 SH-J20 SH-J21 SH-J22 SH-J30 SH-J31: library part CMP-0003623-1, "Shunt, 100mil, Gold plated, Black", Alternate Manufacturer=3M, Alternate PartNumber=969102-0000-DA, Manufacturer=Samtec, Supplier Part Number 1=SNT-100-BK-G-ND
SH-J23 SH-J24 SH-J25 SH-J26 SH-J27 SH-J28 SH-J29: library part CMP-0003761-2, "Shunt, 2.54mm, Gold, Black", Manufacturer="Wurth Elektronik", Supplier Part Number 1=732-2678-ND
TP1 TP2 TP3 TP4 TP5 TP6 TP7 TP8 TP9 TP10 TP11 TP12 TP18 TP19 TP20 TP21 TP22 TP23 TP24 TP26: library part CMP-0003719-1, "Testpoint", Manufacturer="Texas Instruments"
TP25 TP29: library part CMP-0055148-1, "Test Point, Multipurpose, Black, TH", Color=Black, Manufacturer=Keystone, Supplier Part Number 1=36-5011-ND
TP27 TP28 TP30: library part CMP-0055147-1, "Test Point, Multipurpose, Red, TH", Color=Red, Manufacturer=Keystone, Supplier Part Number 1=36-5010-ND
TP31 TP32 TP34 TP35: library part CMP-0055152-1, "Test Point, Miniature, SMT", Manufacturer=Keystone, Supplier Part Number 1=36-5015TR-ND
U1: library part CMP-0038879-1, "20 MHz Mixed Signal Microcontroller with 256 KB Flash, 18432 B SRAM and 74 GPIOs, -40 to 85 degC, 100-pin QFP (PZ), Green (RoHS & no Sb/Br)", Frequency(MHz)=20, Manufacturer="Texas Instruments", Temp Sensor=Yes
U2: "16-Bit Ultra-Low-Power Microcontroller, 128KB Flash, 8KB RAM, USB, 12Bit ADC, 2 USCIs, 32Bit HW MPY, RGC0064B (VQFN-64)", Alternate Manufacturer="Texas Instruments", Alternate PartNumber=MSP430F5528IRGCR, Frequency(MHz)=25, Operating Temperature Range="-40 to 85 C", PartNumber=MSP430F5528IRGCT, Rating=Catalog, Temp Sensor=Yes
U3: library part CMP-0036328-3, "500mA, Adjustable, Low Quiescent Current, Low-Noise, High-PSRR, Single-Output LDO Regulator, DRB0008A (VSON-8)", Manufacturer="Texas Instruments", Operating Temperature Range="-40 to 125 C", Rating=Catalog
U4: library part CMP-0004774-1, "USB to Serial UART, SSOP28", Manufacturer=FTDI, Supplier Part Number 1=768-1007-1-ND
U5: library part CMP-0090815-1, "LDO, Fixed Output, Dual, 3.3V, 10/12/15V, 50mA, Precision Enable, Power-Good, HVSSOP10", Dropout Voltage=200/800mV, Manufacturer="Texas Instruments", Max Supply Voltage=85V, Min Supply Voltage=4V, Nominal Supply Current=100uA, Operating Temperature Range="-40°C to +125°C", Output Voltage=3.3/10/12/15V
U6: library part CMP-0043099-3, "Low-Capacitance 2-Channel +/-15kV ESD Protection Array for High-Speed Data Interfaces, DRY0006A (USON-6)", Breakdown Voltage(Min)(V)=11, IO Capacitance(Typ)(pF)=1.5, IO Leakage Current(nA)=1, Manufacturer="Texas Instruments", Operating Temperature Range="-40 to 85 C", Rating=Catalog
U7: library part CMP-0093481-2, "Stepper Motor Driver with Automatic Microstepping, Silent step Decay Mode  and Auto-torque", Manufacturer="Texas Instruments", Max Supply Voltage=48V, Min Supply Voltage=4.5V, Nominal Supply Current=3-7mA, Operating Temperature Range="-40°C to +125°C", Switching Frequency=500kHz
Y1: library part CMP-0085483-1, "Oscillator, 4 MHz, 700 ppm, 39 pF, SMD", Frequency_Fixed=4MHz, Frequency Tolerance="700 ppm", Load Capacitance="39 pF", Manufacturer=MuRata
Y2: library part CMP-0004566-4, "Crystal, 32.768 kHz, 12.5pF, SMD", Frequency Tolerance="20 ppm", Frequency_Fixed=32.768kHz, Load Capacitance="12.5 pF", Manufacturer="Micro Crystal AG", Supplier Part Number 1=94M8466
ZZ1: library part CMP-0003616-3
ZZ2: library part CMP-0077236-1
ZZ3: library part CMP-0077237-1
ZZ4: library part CMP-0077238-1

## Via types
v1: diameter 0.5, hole 0.35, Top Layer to Bottom Layer, tented both sides, 210 vias
v2: diameter 0.5, hole 0.2, Top Layer to Bottom Layer, tented both sides, 65 vias
v3: diameter 0.5, hole 0.2, Top Layer to Bottom Layer, 22 vias
v4: diameter 3.6, hole 3.6, Top Layer to Bottom Layer, tented both sides, 5 vias
v5: diameter 0.5, hole 0.35, Top Layer to Bottom Layer, tented bottom, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point)
3.3V_COM: C41.1 U4.4 U4.17 | length 12.9
  Top Layer w0.254: U4.4@46.468,114.01 48.322,114.01 49.918,112.414 49.918,110.229 51.337,108.81 U4.17@53.368,108.81 53.431,108.872 C41.1@55.88,108.872
A12: A1.1 R5.2 U1.5 | length 210.1
  Top Layer w0.254: 4.985,65.663 A1.1@5.261,65.663 ; A1.1@6.201,65.573 6.475,65.298 8.548,65.298 8.884,64.962 8.884,64.891 9.723,64.052 11.241,64.052 12.402,62.892 12.402,54.96 14.012,53.35 U1.5@15.847,53.35 ; v1@82.271,4.674 83.261,5.664 110.827,5.664 111.589,6.426 111.589,31.171 R5.2@117.078,36.66
  Signal Layer 2 w0.254: A1.1@6.201,65.573 6.667,65.106 6.667,35.687 6.769,35.585 6.769,33.713 6.381,33.325 6.381,21.133 23.246,4.267 81.864,4.267 v1@82.271,4.674
  other v1: 82.313,4.674
A13: A2.1 R8.2 U1.6 | length 213.1
  Top Layer w0.254: 2.935,61.284 A2.1@3.28,61.629 ; A2.1@2.935,61.705 A2.1@2.961,61.68 ; A2.1@3.24,62.366 4.473,63.598 10.985,63.598 11.948,62.636 11.948,54.772 13.847,52.873 15.824,52.873 U1.6@15.847,52.85 ; v1@84.531,3.378 85.979,4.826 110.947,4.826 112.522,6.401 112.522,27.178 114.3,28.956 R8.2@117.145,28.956
  Signal Layer 2 w0.254: A2.1@3.24,62.366 5.976,59.63 5.976,36.024 5.182,35.23 5.182,20.498 14.148,11.532 14.148,5.055 17.602,1.6 82.707,1.6 84.485,3.378 v1@84.531,3.378
  other v1: 84.531,3.431
A14: A3.1 R13.2 U1.7 | length 183
  Top Layer w0.254: A3.1@8.265,58.445 10.007,58.445 11.494,56.959 11.494,54.584 13.705,52.373 15.824,52.373 U1.7@15.847,52.35 ; v1(86.97,3.734) 86.995,3.759 111.176,3.759 113.436,6.02 113.436,19.787 115.516,21.866 R13.2@117.297,21.866
  Signal Layer 2 w0.254: A3.1@8.265,58.445 7.369,57.55 7.369,43.529 7.42,43.479 7.42,21.688 22.276,6.833 39.776,6.833 41.427,5.182 69.85,5.182 71.603,6.934 83.79,6.934 v1(86.97,3.734)
A15: A4.1 R16.2 U1.8 | length 183.9
  Top Layer w0.254: A4.1@3.595,54.96 10.475,54.96 13.563,51.873 15.824,51.873 U1.8@15.847,51.85 ; v1@12.827,4.293 15.443,1.676 111.176,1.676 114.325,4.826 114.325,12.751 115.6,14.025 R16.2@117.507,14.025
  Signal Layer 2 w0.254: A4.1@3.595,54.96 4.877,53.678 4.877,35.865 4.47,35.458 4.47,19.245 12.827,10.888 v1@12.827,4.293
  other v1: 12.843,4.318
ACCEL/DECEL: D10.2 U1.37 | length 12.7
  Top Layer w0.254: D10.2@15.269,32.534 17.514,34.779 18.202,34.779 23.072,39.65 U1.37@23.072,41.625
AOUT1/OUT1: C52.2 C60.1 J14.1 J22.2 R89.2 TP31.1 U7.4 U7.5 U7.6 | length 19.8
  Top Layer w0.254: C52.2@118.161,45.253 TP31.1@122.277,45.253 ; J14.1@119.121,52.484 119.121,50.647 122.277,47.492 TP31.1@122.277,45.253 ; R89.2@122.277,40.977 TP31.1@122.277,45.253 ; TP31.1@122.477,45.136 122.36,45.253 TP31.1@122.277,45.253
  Bottom Layer w0.254: J14.1@119.121,52.484 119.208,52.571 C60.1@119.208,55.077
AOUT2/OUT2: C60.2 C61.2 J14.2 J24.2 R90.2 TP32.1 U7.7 U7.8 U7.9 | length 46
  Top Layer w0.254: C61.2@118.583,65.407 122.518,65.407 TP32.1@122.53,65.395 122.53,58.961 122.403,58.834 ; J14.2@119.121,58.834 122.403,58.834 ; R90.2@122.129,33.682 126.187,37.74 126.187,57.023 124.377,58.834 122.403,58.834
  Bottom Layer w0.254: J14.2@119.121,58.834 119.208,58.747 C60.2@119.208,56.277
BOUT1/OUT3: C64.2 C65.1 J13.2 J22.1 R91.2 TP34.1 U7.17 U7.18 U7.19 | length 74.6
  Top Layer w0.254: J13.2@119.126,85.014 119.126,88.468 TP34.1@122.631,91.973 ; R91.2@122.389,26.332 124.582,28.524 v1(125.832,28.524)
  Bottom Layer w0.254: C65.1@119.151,82.566 119.151,84.988 J13.2@119.126,85.014 119.393,85.014 125.832,78.575 v1(125.832,28.524)
BOUT2/OUT4: C65.2 C66.2 J13.1 J24.1 R92.2 TP35.1 U7.14 U7.15 U7.16 | length 83.5
  Top Layer w0.254: C66.2@118.608,68.072 118.608,69.56 120.296,71.247 TP35.1@122.479,71.247 122.479,76.733 120.548,78.664 J13.1@119.126,78.664 ; R92.2@122.404,18.455 125.171,21.222 v1(125.171,27.788)
  Bottom Layer w0.254: C65.2@119.151,81.366 119.126,81.34 J13.1@119.126,78.664 121.209,78.664 125.171,74.701 v1(125.171,27.788)
C2K_3V3: J1.1 R1.2 | length 2.8
  Top Layer w0.254: J1.1@75.36,3.009 75.43,2.939 R1.2@78.14,2.939
C2K_AOUT1: R7.2
C2K_AOUT2: R10.2
C2K_BOUT1: R12.2
C2K_BOUT2: R15.2
C2K_DECAY0/SDI/DECAY/EN1: J2.12 R26.2 | length 7.3
  Top Layer w0.254: J2.12@29.64,15.709 30.848,16.916 34.624,16.916 35.712,15.828 R26.2@35.712,15.578
C2K_DECAY1/SDO/RSVD/EN2: J2.14 R25.2 | length 7.1
  Top Layer w0.254: J2.14@29.64,18.249 29.64,18.337 30.861,19.558 34.527,19.558 R25.2@35.695,20.726
C2K_DIR/IN2/PH2: J2.5 R32.2 | length 3.7
  Top Layer w0.254: J2.5@32.18,8.089 32.23,8.039 R32.2@35.84,8.039
C2K_ENABLE/IN1/PH1: J1.9 R33.2 | length 2.7
  Top Layer w0.254: J1.9@75.36,13.169 75.971,13.169 75.991,13.189 R33.2@78.09,13.189
C2K_IPROPI1/IPROPI2: C4.1 J1.14 R18.2 TP42.1 | length 18.9
  Top Layer w0.254: R18.2@66.115,17.939 66.265,18.089 C4.1@68.694,18.089 68.854,18.249 J1.14@72.82,18.249 74.054,19.482 84.244,19.482 TP42.1@84.346,19.38
C2K_IPROPI2/IPROPI3: C5.1 J1.16 R17.2 TP43.1 | length 23.8
  Top Layer w0.254: R17.2@66.09,20.921 68.526,20.921 C5.1@68.694,21.089 70.346,21.089 70.646,20.789 J1.16@72.82,20.789 74.028,21.996 76.725,21.996 77.056,22.327 TP43.1@89.101,22.327
C2K_M0/nSCS/VREF1/EN4: J2.18 R23.2 | length 7.1
  Top Layer w0.254: J2.18@29.64,23.329 29.725,23.329 31.034,24.638 34.577,24.638 R23.2@35.72,23.495
C2K_M1/SCLK/IN4/PH4: J1.13 R27.2 | length 2.8
  Top Layer w0.254: J1.13@75.36,18.249 77.98,18.249 R27.2@78.09,18.139
C2K_MODE2/IPROPI4: C6.1 J1.18 R14.2 TP44.1 | length 19.6
  Top Layer w0.254: R14.2@66.09,23.439 66.74,24.089 C6.1@68.694,24.089 69.485,24.089 70.245,23.329 J1.18@72.82,23.329 74.181,24.689 80.01,24.689 80.34,24.359 TP44.1@84.455,24.359
C2K_MODE/MODE1: J2.13 R11.2 | length 3.7
  Top Layer w0.254: J2.13@32.18,18.249 R11.2@35.84,18.249
C2K_nFAULT: J1.15 R6.2 | length 2.8
  Top Layer w0.254: J1.15@75.36,20.789 78.015,20.789 R6.2@78.09,20.864
C2K_nHOME/OCPM: J2.1 R9.2 | length 3.7
  Top Layer w0.254: J2.1@32.18,3.009 32.3,2.889 R9.2@35.84,2.889
C2K_nSLEEP: J2.7 R34.2 | length 3.7
  Top Layer w0.254: J2.7@32.18,10.629 32.24,10.689 R34.2@35.84,10.689
C2K_RSVD/IPROPI1: C3.1 J1.12 R21.2 TP41.1 | length 24.7
  Top Layer w0.254: R21.2@66.09,14.992 68.659,14.992 C3.1@68.694,15.027 72.139,15.027 J1.12@72.82,15.709 74.003,16.891 77.089,16.891 77.115,16.865 79.447,16.865 80.142,16.17 81.097,16.17 81.792,16.865 88.133,16.865 TP41.1@89.073,17.805
C2K_STEP/IN3/PH3: J2.20 R30.2 | length 7.4
  Top Layer w0.254: J2.20@29.64,25.869 29.64,26.249 30.509,27.118 34.46,27.118 R30.2@35.771,25.806
C2K_TOFF/RSVD/EN3: J2.3 R24.2 | length 3.7
  Top Layer w0.254: J2.3@32.18,5.549 R24.2@35.865,5.549
C2K_VREF: J1.20 R19.1 TP45.1 | length 21.6
  Top Layer w0.254: R19.1@69.562,27.991 71.684,25.869 J1.20@72.82,25.869 72.82,26.288 73.609,27.076 87.922,27.076 TP45.1@89.09,25.908
DIR/IN2: J8.12 R32.1 U7.40 | length 90.7
  Top Layer w0.254: R32.1@36.84,8.039 38.895,8.039 69.312,38.456 v1@69.312,41.148 ; J8.12@66.473,49.403 79.546,49.403 91.374,61.231 U7.40@94.689,61.231
  Bottom Layer w0.254: v1(69.291,41.123) 73,44.831 v1(73,49.416)
DM: R73.2 U4.16 | length 10.7
  Top Layer w0.254: R73.2@43.628,107.344 44.368,106.604 49.974,106.604 51.53,108.16 U4.16@53.368,108.16
DP: R71.2 U4.15 | length 10.9
  Top Layer w0.254: R71.2@43.612,105.745 52.363,105.745 53.368,106.75 U4.15@53.368,107.51
DRV_ENABLE: D9.2 U1.36 | length 16.3
  Top Layer w0.254: D9.2@12.08,32.518 12.08,34.112 13.201,35.233 18.013,35.233 22.549,39.769 22.549,41.625 U1.36@22.572,41.625
DVDD: C49.1 TP28.1 U7.24 | length 18.8
  Top Layer w0.254: TP28.1@83.769,84.455 83.766,84.452 83.766,82.807 90.602,75.971 90.602,74.549 91.199,73.951 91.973,73.951 91.973,72.847 93.43,71.391 U7.24@94.689,71.391
ENABLE/IN1: J8.14 R33.1 U7.41 | length 70
  Top Layer w0.254: J8.14@66.473,46.863 v1(77.318,46.863) 77.648,46.863 91.381,60.596 U7.41@94.689,60.596 ; R33.1@79.09,13.189 v1@80.264,13.189
  Bottom Layer w0.254: v1(77.318,46.863) 77.318,31.12 78.486,29.952 78.486,14.973 v1(80.289,13.17)
EVM_STATUS: D6.2 U1.34 | length 20.7
  Top Layer w0.254: D6.2@5.844,32.507 6.243,32.906 6.783,32.906 7.24,33.364 7.24,33.883 9.499,36.141 17.637,36.141 21.549,40.053 21.549,41.602 U1.34@21.572,41.625
EZFET_AVBUS: C24.1 R56.1 R61.2 U2.1 | length 11.4
  Top Layer w0.152: R56.1@19.144,116.967 19.144,115.838 R61.2@19.352,115.63 ; R61.2@19.252,115.63 19.252,114.581 C24.1@19.3,114.533 ; 20.222,110.058 U2.1@22.906,107.373
  Top Layer w0.254: C24.1@19.352,114.585 19.67,114.585 20.201,114.054 20.201,110.079 20.222,110.058
EZFET_AVCC2ADC: C22.1 R55.1 R60.2 U2.2 | length 12
  Top Layer w0.152: R55.1@19.255,113.459 19.255,110.317 ; U2.2@22.553,107.02 19.774,109.798 19.746,109.798 19.54,110.005 19.54,110.033 19.255,110.317 ; 19.255,110.317 19.255,112.398 19.255,110.317
EZFET_D_N: C42.1 R72.2 U2.52 | length 15.7
  Top Layer w0.254: U2.52@28.068,103.126 28.143,103.126 28.143,103.259 28.26,103.375 31.069,103.375 33.141,105.448 35.391,105.448 C42.1@37.453,107.51 37.453,111.672 R72.2@37.616,111.835
EZFET_D_P: C43.1 R75.2 R76.1 R77.2 U2.50 | length 17.1
  Top Layer w0.254: U2.50@28.775,102.419 28.841,102.419 28.841,102.559 28.95,102.668 31.603,102.668 R76.1@32.034,103.099 32.034,103.139 R77.2@32.757,103.862 32.757,104.055 34.716,104.055 37.369,106.708 38.245,106.708 38.864,107.327 C43.1@38.864,107.51 38.656,107.717 38.656,111.817 38.864,111.817 R75.2@38.846,111.835
EZFET_LED0: R58.2 U2.20 | length 8.6
  Top Layer w0.254: R58.2@12.928,104.734 12.928,103.483 16.618,99.793 18.367,99.793 U2.20@18.664,100.09
EZFET_LED1: R59.2 U2.21 | length 10.1
  Top Layer w0.254: R59.2@11.608,104.734 12.474,103.868 12.474,103.295 16.43,99.339 18.612,99.339 19.009,99.737 U2.21@19.017,99.737
EZFET_PUR: R76.2 U2.51 | length 7.2
  Top Layer w0.152: v1(27.866,102.208) 28.422,102.764 U2.51@28.422,102.777
  Top Layer w0.254: v1(31.039,100.575) 31.207,100.575 32.258,101.626 R76.2@32.883,102.251
  Bottom Layer w0.254: v1(27.866,102.208) 28.64,102.208 30.273,100.575 v1(31.039,100.575)
EZFET_RST: C23.1 J9.11 R57.1 U2.64 | length 33.7
  Top Layer w0.254: C23.1@12.903,115.402 14.509,115.402 R57.1@14.529,115.383 14.529,118.025 14.63,118.126 ; J9.11@16.419,123.632 15.159,122.372 12.348,122.372 11.578,121.602 11.578,119.502 12.954,118.126 14.63,118.126 ; U2.64@23.826,107.368 23.826,107.373 24.128,107.675 24.128,108.134 20.689,111.573 20.689,117.259 19.821,118.126 14.63,118.126
EZFET_TCK: J9.7 U2.63 | length 22.8
  Top Layer w0.254: J9.7@21.406,123.577 20.201,122.372 18.572,122.372 17.714,121.514 17.714,120.56 18.389,119.885 19.745,119.885 21.143,118.488 21.143,112.176 24.582,108.737 24.582,107.422 U2.63@24.179,107.02
EZFET_TDI: J9.3 U2.61 | length 21.3
  Top Layer w0.254: U2.61@24.886,106.313 25.49,106.916 25.49,109.134 22.794,111.829 22.794,113.864 22.943,114.012 22.943,115.592 22.794,115.741 22.794,121.637 23.439,122.282 25.191,122.282 J9.3@26.486,123.577
EZFET_TDO: J9.1 U2.60 | length 22.1
  Top Layer w0.254: U2.60@25.24,105.959 25.542,106.261 25.542,106.326 25.944,106.728 25.944,109.362 23.629,111.677 23.629,118.949 23.605,118.974 24.363,119.732 25.334,120.703 25.334,121.565 26.051,122.282 27.731,122.282 J9.1@29.026,123.577
EZFET_TEST: J9.8 U2.59 | length 18.4
  Top Layer w0.254: J9.8@21.499,121.092 22.301,120.29 v1@22.301,114.859 ; v1(25.039,104.973) 25.039,105.051 25.591,105.603 U2.59@25.593,105.606
  Bottom Layer w0.254: v1(22.317,114.859) 22.317,107.695 v1(25.039,104.973)
EZFET_TMS: J9.5 U2.62 | length 21.7
  Top Layer w0.254: J9.5@23.946,123.577 22.778,122.409 21.017,122.409 20.254,121.647 20.254,120.56 21.664,119.15 21.664,112.317 25.036,108.945 25.036,107.169 U2.62@24.533,106.666
EZFET_UARTRXD: R66.1 R70.2 U2.38 | length 33.6
  Top Layer w0.254: U2.38@25.593,97.615 26.23,96.979 26.23,94.038 25.748,93.556 25.766,93.538 R66.1@25.766,91.538 ; v1@42.405,111.843 R70.2@42.405,113.383
  Bottom Layer w0.254: v1(26.268,95.883) 29.241,98.857 33.833,98.857 42.418,107.442 v1(42.418,111.989)
EZFET_UARTTXD: R67.1 R69.1 U2.37 | length 36.2
  Top Layer w0.254: R67.1@23.219,91.536 23.219,93.57 ; U2.37@25.24,97.262 25.542,96.96 25.542,95.896 23.218,93.572 ; v1(41.695,114.325) 41.695,115.191 41.672,115.214 42.373,115.916 R69.1@42.373,116.053 ; 23.218,93.572 23.219,93.57
  Bottom Layer w0.254: v1(25.568,96.368) 25.57,96.368 28.852,99.65 33.479,99.65 41.695,107.866 v1(41.695,114.325)
EZFET_USB_Shield: C47.1 J11.6 J11.7 J11.8 J11.9 J11.10 J11.11 R78.2 | length 20.2
  Top Layer w0.254: J11.10@33.791,123.982 J11.9@36.803,123.982 ; J11.11@35.278,121.682 36.803,123.207 J11.9@36.803,123.982 ; J11.8@38.678,123.982 J11.8@38.678,123.207 ; J11.7@41.691,123.982 40.203,122.495 J11.6@40.203,121.682 ; C47.1@44.764,121.235 44.764,121.756 ; R78.2@44.764,122.834 44.764,121.756 ; J11.9@36.803,123.982 37.903,123.982 J11.8@38.678,123.207 ; J11.8@38.678,123.207 J11.6@40.203,121.682 ; J11.6@40.203,121.682 44.691,121.682 44.764,121.756
EZFET_V18: C28.1 U2.55 | length 3.3
  Top Layer w0.254: U2.55@27.008,104.191 28.049,105.231 28.049,105.884 28.346,106.181 C28.1@28.909,106.743
EZFET_VBUS: C20.1 C21.1 C35.1 C36.1 C37.1 C48.1 D3.1 R56.2 U2.53 U3.5 U3.8 U4.20 U6.1 | length 74.7
  Top Layer w0.152: v1(17.256,116.967) R56.2@18.244,116.967 ; C36.1@32.54,113.653 32.605,113.588 32.605,113.264 U3.8@34.095,111.775 ; U3.8@34.095,111.63 U3.8@34.095,111.775 ; U3.5@36.045,111.63 36.045,111.775 35.826,111.994 35.826,112.016 35.635,112.206 34.504,112.206 34.313,112.016 34.313,111.994 U3.8@34.095,111.775
  Top Layer w0.254: U2.53@27.715,103.484 29.119,104.843 ; 29.135,104.827 30.167,104.827 C20.1@30.498,105.157 30.777,104.878 v1(31.75,104.878) ; v1(30.686,113.669) C35.1@31.386,113.669 ; v1(32.536,100.813) 34.407,98.942 C21.1@34.407,98.867 ; C36.1@32.54,113.653 33.658,113.653 33.9,113.653 34.85,114.603 C48.1@35.405,114.603 36.083,115.28 v1(36.165,115.28) 35.883,115.562 D3.1@35.883,117.704 36.355,117.704 U6.1@37.009,118.358 ; v1@51.402,110.76 U4.20@53.368,110.76
  Bottom Layer w0.254: v1(17.256,116.967) 27.073,116.967 28.862,115.178 28.862,114.645 29.837,113.669 v1(30.686,113.669) ; v1(32.536,100.813) 31.772,101.577 31.681,101.577 31.681,104.809 v1(31.75,104.878) 32.827,105.955 32.827,107.723 31.442,109.108 31.442,110.627 36.095,115.28 v1(36.165,115.28) 36.165,115.278 36.539,114.904 46.338,114.904 50.404,110.839 v1(51.391,110.839)
EZFET_VCC: C31.1 C32.1 C33.1 C34.1 J10.9 R55.2 R57.2 R62.1 R63.1 R68.2 R74.2 U2.11 U2.15 U2.40 | length 76.7
  Top Layer w0.152: C31.1@17.05,104.378 C31.1@17.15,104.278
  Top Layer w0.254: R57.2@14.529,114.183 15.653,114.183 16.378,113.459 v1(17.295,113.459) R55.2@18.055,113.459 ; v1(16.15,103.678) C31.1@16.15,104.578 ; C31.1@16.4,104.778 16.456,104.834 18.375,104.834 ; C31.1@17.15,104.278 v1(17.15,103.678) 17.15,103.23 U2.15@17.957,102.424 ; C33.1@18.355,106.828 C32.1@19.39,106.828 ; C33.1@18.555,106.728 18.555,106.183 18.35,105.978 v1(18.25,105.978) 18.25,104.959 18.375,104.834 ; U2.11@19.371,103.838 18.375,104.834 ; v1(24.206,115.773) 27.373,115.773 R62.1@27.461,115.685 R63.1@28.512,115.685 ; U2.40@26.301,98.322 26.74,97.883 27.355,97.883 28.084,97.155 28.133,97.155 v1(28.597,96.691) 28.597,95.428 C34.1@28.304,95.135 ; v1(36.736,100.285) R74.2@36.736,101.469 ; R74.2@36.83,101.563 R74.2@36.736,101.469 ; R68.2@37.655,102.65 36.736,101.731 R74.2@36.736,101.469
  Bottom Layer w0.254: v1(17.15,103.678) 27.094,93.734 27.094,93.728 ; v1(17.295,113.459) 18.405,113.459 ; v1(18.25,105.978) 18.25,113.303 18.405,113.459 ; J10.9@22.149,87.249 22.149,88.783 27.094,93.728 ; v1(24.206,115.773) 21.67,115.773 19.355,113.459 18.405,113.459 ; v1(36.736,100.285) 33.141,96.691 v1(28.597,96.691) 28.597,95.231 27.094,93.728
EZFET_Vcore: C29.1 U2.17 | length 4.9
  Top Layer w0.254: C29.1@14.578,104.734 14.45,104.605 14.45,104.304 U2.17@17.603,101.151
EZFET_VREF: C25.1 U2.9 | length 2.7
  Top Layer w0.254: U2.9@20.078,104.545 19.65,104.972 19.65,105.676 20.55,106.575 C25.1@20.55,106.728
EZFET_VUSB: C30.1 U2.54 | length 3.1
  Top Layer w0.254: U2.54@27.361,103.838 28.577,105.051 C30.1@29.608,106.043
EZFET_XT2IN: U2.57 Y1.1 | length 5.1
  Top Layer w0.254: U2.57@26.301,104.898 26.95,105.548 26.95,107.478 Y1.1@28.55,109.078
EZFET_XT2OUT: U2.58 Y1.3 | length 5.9
  Top Layer w0.254: U2.58@25.947,105.252 26.433,105.738 26.433,109.694 26.15,109.978 Y1.3@26.15,110.878
FAULT: D12.2 U1.40 | length 10.2
  Top Layer w0.254: D12.2@21.715,32.563 21.715,37.008 24.549,39.843 24.549,41.602 U1.40@24.572,41.625