# Altium PCB MD040_RevA_ASCII.PcbDoc (part 3 of 6)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 5000 x 5000 mil, 4 copper layers (Top Layer, Signal Layer 1, Signal Layer 2, Bottom Layer), stack 61.2 mil thick; 342 components, 206 nets, 933 pads, 352 vias.
Unrouted connection lines stored in the file: 124.

## Design rules (kind name [scope] priority, off if disabled: settings) (continued)
PolygonConnect PolygonConnect_90 [All vs IsNamedPolygon('TOP_LAYER_VM_P239')] p5: thpad.connectstyle=Direct thpad.reliefconductorwidth=10 thpad.reliefentries=4 thpad.polygonreliefangle="90 Angle" thpad.airgapwidth=10 smdpad.connectstyle=Direct smdpad.reliefconductorwidth=10 smdpad.reliefentries=4 smdpad.polygonreliefangle="90 Angle" smdpad.airgapwidth=10 via.connectstyle=Relief via.reliefconductorwidth=10 via.reliefentries=4 via.polygonreliefangle="90 Angle" via.airgapwidth=10
PolygonConnect PolygonConnect_89 [All vs IsNamedPolygon('TOP_LAYER_BOUT1_P240')] p6: thpad.connectstyle=Direct thpad.reliefconductorwidth=10 thpad.reliefentries=4 thpad.polygonreliefangle="90 Angle" thpad.airgapwidth=10 smdpad.connectstyle=Direct smdpad.reliefconductorwidth=10 smdpad.reliefentries=4 smdpad.polygonreliefangle="90 Angle" smdpad.airgapwidth=10 via.connectstyle=Relief via.reliefconductorwidth=10 via.reliefentries=4 via.polygonreliefangle="90 Angle" via.airgapwidth=10
PolygonConnect PolygonConnect_88 [All vs IsNamedPolygon('BOTTOM_LAYER_VM_P080')] p7: thpad.connectstyle=Direct thpad.reliefconductorwidth=10 thpad.reliefentries=4 thpad.polygonreliefangle="90 Angle" thpad.airgapwidth=10 smdpad.connectstyle=Direct smdpad.reliefconductorwidth=10 smdpad.reliefentries=4 smdpad.polygonreliefangle="90 Angle" smdpad.airgapwidth=10 via.connectstyle=Relief via.reliefconductorwidth=10 via.reliefentries=4 via.polygonreliefangle="90 Angle" via.airgapwidth=10
PolygonConnect PolygonConnect_87 [All vs IsNamedPolygon('TOP_LAYER_VM_P125')] p8: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_86 [All vs IsNamedPolygon('BOTTOM_LAYER_VM_P080')] p9: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_85 [All vs IsNamedPolygon('BOTTOM_LAYER_OUT2_P211')] p10: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_84 [All vs IsNamedPolygon('BOTTOM_LAYER_OUT1_P205')] p11: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_83 [All vs IsNamedPolygon('BOTTOM_LAYER_OUT1_P205')] p12: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_82 [All vs IsNamedPolygon('BOTTOM_LAYER_GND_P204')] p13: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_81 [All vs IsNamedPolygon('TOP_LAYER_GND_P237')] p14: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_80 [All vs IsNamedPolygon('TOP_LAYER_GND_P086')] p15: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_79 [All vs IsNamedPolygon('TOP_LAYER_VM_P229')] p16: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_78 [All vs IsNamedPolygon('TOP_LAYER_GND_P086')] p17: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_77 [All vs IsNamedPolygon('TOP_LAYER_OUT1_P221')] p18: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_76 [All vs IsNamedPolygon('TOP_LAYER_OUT2_P173')] p19: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_75 [All vs IsNamedPolygon('TOP_LAYER_OUT2_P173')] p20: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_74 [All vs IsNamedPolygon('TOP_LAYER_OUT2_P173')] p21: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_73 [All vs IsNamedPolygon('TOP_LAYER_OUT1_P221')] p22: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_72 [All vs IsNamedPolygon('TOP_LAYER_GND_P121')] p23: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_71 [All vs IsNamedPolygon('TOP_LAYER_OUT2_P173') Or  IsNamedPolygon('TOP_LAYER_OUT1_P129')] p24: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_70 [All vs IsNamedPolygon('TOP_LAYER_OUT2_P173')] p25: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_69 [All vs IsNamedPolygon('TOP_LAYER_OUT1_P129')] p26: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_68 [All vs IsNamedPolygon('TOP_LAYER_VM_P085')] p27: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_67 [All vs IsNamedPolygon('BOTTOM_LAYER_P_IN_P174')] p28: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_66 [All vs IsNamedPolygon('BOTTOM_LAYER_NETF1_2_P203')] p29: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_65 [All vs IsNamedPolygon('BOTTOM_LAYER_VBAT_P165')] p30: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_64 [All vs IsNamedPolygon('TOP_LAYER_VM_P167')] p31: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_63 [All vs IsNamedPolygon('TOP_LAYER_VM_P167')] p32: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_62 [All vs IsNamedPolygon('TOP_LAYER_VM_P171')] p33: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_61 [All vs IsNamedPolygon('SIGNAL_LAYER_2_GND_P199')] p34: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_60 [All vs IsNamedPolygon('SIGNAL_LAYER_2_NETF1_2_P196')] p35: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_59 [All vs IsNamedPolygon('SIGNAL_LAYER_2_VBAT_P197')] p36: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_58 [All vs IsNamedPolygon('SIGNAL_LAYER_2_P_IN_P198')] p37: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_57 [All vs IsNamedPolygon('SIGNAL_LAYER_2_3V3_P194')] p38: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_56 [All vs IsNamedPolygon('TOP_LAYER_NETF1_2_P207')] p39: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_55 [All vs IsNamedPolygon('TOP_LAYER_VBAT_P223')] p40: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_54 [All vs IsNamedPolygon('TOP_LAYER_P_IN_P227')] p41: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_53 [All vs IsNamedPolygon('TOP_LAYER_GND_P086')] p42: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_52 [All vs IsNamedPolygon('SIGNAL_LAYER_2_VM_P177') Or  IsNamedPolygon('SIGNAL_LAYER_2_VM_P179') Or  IsNamedPolygon('SIGNAL_LAYER_2_VM_P160') Or  IsNamedPolygon('SIGNAL_LAYER_2_VM_P175') Or  IsNamedPolygon('SIGNAL_LAYER_2_VM_P181')] p43: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_51 [All vs IsNamedPolygon('SIGNAL_LAYER_2_EZFET_VBUS_P136')] p44: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_50 [All vs IsNamedPolygon('SIGNAL_LAYER_2_EZFET_VCC_P132')] p45: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_49 [All vs IsNamedPolygon('SIGNAL_LAYER_2_MCU_3V3_P192')] p46: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_48 [All vs IsNamedPolygon('SIGNAL_LAYER_1_GND_P190')] p47: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_47 [All vs IsNamedPolygon('SIGNAL_LAYER_1_GND_P184')] p48: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_46 [All vs IsNamedPolygon('BOTTOM_LAYER_GND_P241')] p49: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_45 [All vs IsNamedPolygon('BOTTOM_LAYER_GND_P241')] p50: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_44 [All vs IsNamedPolygon('BOTTOM_LAYER_OUT2_P163')] p51: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_43 [All vs IsNamedPolygon('BOTTOM_LAYER_VM_P166')] p52: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_42 [All vs IsNamedPolygon('BOTTOM_LAYER_VM_P235')] p53: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_41 [All vs IsNamedPolygon('BOTTOM_LAYER_OUT1_P164')] p54: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_40 [All vs IsNamedPolygon('BOTTOM_LAYER_GND_P162')] p55: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_39 [All vs IsNamedPolygon('SIGNAL_LAYER_2_VM_P160')] p56: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_38 [All vs IsNamedPolygon('SIGNAL_LAYER_2_NONET_P138')] p57: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_37 [All vs IsNamedPolygon('SIGNAL_LAYER_1_VM_P146')] p58: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_36 [All vs IsNamedPolygon('SIGNAL_LAYER_2_GND_P156')] p59: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_35 [All vs IsNamedPolygon('BOTTOM_LAYER_EZFET_USB_SHIELD_P219')] p60: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_34 [All vs IsNamedPolygon('SIGNAL_LAYER_1_VM_P144')] p61: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_33 [All vs IsNamedPolygon('SIGNAL_LAYER_1_VM_P148') Or  IsNamedPolygon('SIGNAL_LAYER_1_VM_P148')] p62: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_32 [All vs IsNamedPolygon('SIGNAL_LAYER_1_GND_P154')] p63: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_31 [All vs IsNamedPolygon('SIGNAL_LAYER_2_NONET_P138')] p64: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_30 [All vs IsNamedPolygon('SIGNAL_LAYER_2_GND_P082')] p65: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_29 [All vs IsNamedPolygon('TOP_LAYER_GND_P076')] p66: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_28 [All vs IsNamedPolygon('TOP_LAYER_GND_P087')] p67: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_27 [All vs IsNamedPolygon('TOP_LAYER_VM_P127') Or  IsNamedPolygon('TOP_LAYER_VM_P085')] p68: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_26 [All vs IsNamedPolygon('TOP_LAYER_GND_P117')] p69: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_25 [All vs IsNamedPolygon('TOP_LAYER_OUT1_P129') Or  IsNamedPolygon('TOP_LAYER_OUT2_P173')] p70: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_24 [All vs IsNamedPolygon('SIGNAL_LAYER_2_NONET_P113')] p71: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_23 [All vs IsNamedPolygon('BOTTOM_LAYER_NONET_P115')] p72: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_22 [All vs IsNamedPolygon('SIGNAL_LAYER_1_NONET_P111')] p73: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_21 [All vs IsNamedPolygon('TOP_LAYER_NONET_P083')] p74: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_20 [All vs IsNamedPolygon('TOP_LAYER_NONET_P105')] p75: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_19 [All vs IsNamedPolygon('TOP_LAYER_OUT2_P107')] p76: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_18 [All vs IsNamedPolygon('TOP_LAYER_NONET_P101')] p77: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_17 [All vs IsNamedPolygon('TOP_LAYER_OUT1_P103')] p78: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_16 [All vs IsNamedPolygon('TOP_LAYER_OUT1_P000')] p79: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_15 [All vs IsNamedPolygon('TOP_LAYER_NONET_P093')] p80: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_14 [All vs IsNamedPolygon('TOP_LAYER_OUT2_P099')] p81: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_13 [All vs IsNamedPolygon('TOP_LAYER_OUT1_P000')] p82: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_12 [All vs IsNamedPolygon('BOTTOM_LAYER_NONET_P079') Or  IsNamedPolygon('SIGNAL_LAYER_2_NONET_P078') Or  IsNamedPolygon('SIGNAL_LAYER_1_NONET_P077') Or  IsNamedPolygon('TOP_LAYER_NONET_P083') Or  IsNamedPolygon('BOTTOM_LAYER_NONET_P072') Or  IsNamedPolygon('SIGNAL_LAYER_2_NONET_P070') Or  IsNamedPolygon('SIGNAL_LAYER_1_NONET_P059') Or  IsNamedPolygon('TOP_LAYER_OUT2_P058') Or  IsNamedPolygon('BOTTOM_LAYER_NONET_P056') Or  IsNamedPolygon('SIGNAL_LAYER_2_NONET_P054') Or  IsNamedPolygon('SIGNAL_LAYER_1_NONET_P052') Or  IsNamedPolygon('TOP_LAYER_OUT1_P050') Or  IsNamedPolygon('BOTTOM_LAYER_VM_P044') Or  IsNamedPolygon('SIGNAL_LAYER_2_VM_P042') Or  IsNamedPolygon('SIGNAL_LAYER_1_VM_P040') Or  IsNamedPolygon('TOP_LAYER_VM_P038') Or  IsNamedPolygon('BOTTOM_LAYER_VM_P036') Or  IsNamedPolygon('SIGNAL_LAYER_2_VM_P018') Or  IsNamedPolygon('SIGNAL_LAYER_1_VM_P016') Or  IsNamedPolygon('TOP_LAYER_VM_P002')] p83: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_11 [All vs IsNamedPolygon('TOP_LAYER_NONET_P089') Or  IsNamedPolygon('TOP_LAYER_NONET_P090')] p84: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_10 [All vs IsNamedPolygon('BOTTOM_LAYER_EZFET_USB_SHIELD_P002') Or  IsNamedPolygon('TOP_LAYER_EZFET_USB_SHIELD_P201') Or  IsNamedPolygon('SIGNAL_LAYER_2_EZFET_VBUS_P018') Or  IsNamedPolygon('SIGNAL_LAYER_2_EZFET_VCC_P016')] p85: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_9 [All vs IsNamedPolygon('TOP_LAYER_VM_P123') Or  IsNamedPolygon('TOP_LAYER_VM_P123') Or  IsNamedPolygon('TOP_LAYER_VM_P123')] p86: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_8 [All vs IsNamedPolygon('TOP_LAYER_NONET_P072')] p87: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_7 [All vs IsNamedPolygon('TOP_LAYER_NONET_P072')] p88: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_6 [All vs IsNamedPolygon('TOP_LAYER_VM_P042')] p89: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_5 [All vs IsNamedPolygon('TOP_LAYER_VM_P044')] p90: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_4 [All vs IsNamedPolygon('TOP_LAYER_VM_P046')] p91: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_3 [All vs IsNamedPolygon('TOP_LAYER_GND_P036') Or  IsNamedPolygon('TOP_LAYER_OUT2_P040') Or  IsNamedPolygon('TOP_LAYER_OUT1_P038')] p92: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_2 [InNet('EZFET_VBUS') vs IsNamedPolygon('TOP_LAYER_EZFET_VBUS_P008')] p93: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_1 [InNetClass('Power-Net') vs IsNamedPolygon('TOP_LAYER_EZFET_USB_SHIELD_P201')] p94: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect [All] p95: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
RoutingCorners [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 cornerstyle=45-Degree minsetback=100 maxsetback=100
RoutingLayers [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 top layer=Automatic mid layer 1=Automatic mid layer 2=Automatic bottom layer=Automatic
RoutingPriority [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0
RoutingTopology [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 topology=Shortest
RoutingVias [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 holewidth=16 width=34 viastyle="Through Hole" minholewidth=7.87 minwidth=26 maxholewidth=40 maxwidth=65
RoutingVias ThermalPadVias [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=63 holewidth=7.87 width=19.68 viastyle="Through Hole" minholewidth=7.87 minwidth=19.68 maxholewidth=12.99 maxwidth=23.62 // Protel DXP Scope 1 Expression Was: IsVia and InAnyComponent
RoutingVias ThermalPadVias [IsVia and InAnyComponent] p1: holewidth=7.87 width=19.68 viastyle="Through Hole" minholewidth=7.87 minwidth=19.68 maxholewidth=12.99 maxwidth=23.62
RoutingVias [All] p2: holewidth=16 width=34 viastyle="Through Hole" minholewidth=7.87 minwidth=26 maxholewidth=40 maxwidth=65
ShortCircuit [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 allowed=FALSE
SilkToBoardRegionClearance [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=130 // Protel DXP Scope 1 Expression Was: Not ((IsComment or IsDesignator) And (Hide <> 'False')) and not InRegion(1000,500,4000,800)
SilkToBoardRegionClearance [Not ((IsComment or IsDesignator) And (Hide <> 'False')) and not InRegion(1000,500,4000,800)] p1:
SilkToSilkClearance [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0
SilkToSilkClearance SilkToSilkClearance_Pb-FreeLogo [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=120 // Protel DXP Scope 2 Expression Was: (HasFootprint('Pb-Free_Overlay_Medium') OR HasFootprint('Pb-Free_Overlay_Small'))
SilkToSilkClearance SilkToSilkClearance_Pb-FreeLogo [(HasFootprint('Pb-Free_Overlay_Medium') OR HasFootprint('Pb-Free_Overlay_Small')) vs (HasFootprint('Pb-Free_Overlay_Medium') OR HasFootprint('Pb-Free_Overlay_Small'))] p1: silktosilkclearance=0
SilkToSilkClearance [All] p2: silktosilkclearance=3.94
SilkToSolderMaskClearance "Silk to Solder Mask Opening" [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0
SilkToSolderMaskClearance SilkToComponentPadClearance [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=87 // Protel DXP Scope 1 Expression Was: (IsPad or IsFill or IsRegion) and InAnycomponent
SilkToSolderMaskClearance SilkToComponentPadClearance [(IsPad or IsFill or IsRegion) and InAnycomponent] p1: minsilkscreentomaskgap=5 clearancetoexposedcopper=TRUE
SilkToSolderMaskClearance "Silk to Solder Mask Opening" [All] p2: minsilkscreentomaskgap=3.94 clearancetoexposedcopper=FALSE
SolderMaskExpansion [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 expansion=1.97
SolderMaskExpansion [All] p1: expansion=1.97 istentingtop=FALSE
UnRoutedNet [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0
UnRoutedNet [All] p1: checkbadconnections=TRUE
UnpouredPolygon [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0
Width [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 maxlimit=100 minlimit=6 preferedwidth=10
Width [All] p1: maxlimit=100 minlimit=6 preferedwidth=10 checkconnectedcopper=TRUE
14 further rules are at their usual default settings.

## Classes and differential pairs
component class MD040_Hardware_RevA: !PCB1 FID1 FID2 FID3 H1 H1_Nut H2 H2_Nut H3 H3_Nut H4 H4_Nut LBL1 LOGO1 Logo2 Logo3 Logo4 Logo5 Logo6 LOGO7 ZZ1 ZZ2 ZZ3 ZZ4
component class MD040_Motor_control_RevA: A1 A2 A3 A4 C1 C2 C3 C4 C5 C6 C7 C8 C9 C10 C11 C12 C13 C14 C15 C16 C17 C18 C19 C62 C72 C73 C74 J1 J2 J3 J4 J5 J6 J7 J8 J25 J26 R1 R2 R3 R4 R5 R6 R7 R8 R9 R10 R11 R12 R13 R14 R15 R16 R17 R18 R19 R20 R21 R22 R23 R24 R25 R26 R27 R29 R30 R32 R33 R34 R35 R39 R40 R41 R42 R44 R49 R54 SH-J1 SH-J2 SH-J3 SH-J4 SH-J5 SH-J6 SH-J7 SH-J8 SH-J9 SH-J10 SH-J11 SH-J12 SH-J13 SH-J14 SH-J15 SH-J16 SH-J17 SH-J30 SH-J31 TP1 TP2 TP3 TP4 TP5 TP6 TP7 TP8 TP9 TP10 TP11 TP12 TP13 TP14 TP15 TP16 TP17 TP18 TP19 TP20 TP21 TP22 TP23 TP24 TP25 TP26 TP27 TP37 TP38 TP39 TP40 TP41 TP42 TP43 TP44 TP45 TP46 U1 Y2
component class Shunt: SH-J1 SH-J2 SH-J3 SH-J4 SH-J5 SH-J6 SH-J7 SH-J8 SH-J9 SH-J10 SH-J11 SH-J12 SH-J13 SH-J14 SH-J15 SH-J16 SH-J17 SH-J18 SH-J19 SH-J20 SH-J21 SH-J22 SH-J23 SH-J24 SH-J25 SH-J26 SH-J27 SH-J28 SH-J29 SH-J30 SH-J31
component class MD040_Motor_Driver_RevA: C49 C50 C51 C52 C53 C54 C55 C56 C57 C58 C59 C60 C61 C63 C64 C65 C66 C67 C68 C69 C70 C71 D4 D5 D6 D7 D8 D9 D10 D11 D12 D13 F1 J12 J13 J14 J15 J16 J17 J18 J19 J20 J21 J22 J23 J24 J27 J28 Q1 R79 R80 R81 R82 R83 R84 R85 R86 R87 R88 R89 R90 R91 R92 R93 R94 R95 R96 R97 R98 R99 R100 R101 R102 R103 R104 R105 R106 R107 R108 R109 R110 R111 R112 R113 R114 R115 R116 R117 R118 S1 SH-J18 SH-J19 SH-J20 SH-J21 SH-J22 TP28 TP29 TP30 TP31 TP32 TP34 TP35 TP36 U7
net class Power-Net: EZFET_VBUS EZFET_VCC GND MCU_3V3
component class Header: J3 J4 J5 J6 J7 J8 J9 J10 J16 J17 J18 J19 J20 J25 J26 J27
component class MD040_ezFET_RevA: C20 C21 C22 C23 C24 C25 C26 C27 C28 C29 C30 C31 C32 C33 C34 C35 C36 C37 C38 C39 C40 C41 C42 C43 C44 C45 C46 C47 C48 D1 D2 D3 J9 J10 J11 L1 L2 R55 R56 R57 R58 R59 R60 R61 R62 R63 R64 R65 R66 R67 R68 R69 R70 R71 R72 R73 R74 R75 R76 R77 R78 SH-J23 SH-J24 SH-J25 SH-J26 SH-J27 SH-J28 SH-J29 U2 U3 U4 U5 U6 Y1
component class Logo: Logo3
component class FiducialMark: FID1 FID2 FID3
component class AssemblyNote: ZZ1 ZZ2 ZZ3 ZZ4
component class Label: LBL1
differential pair USB_D: +USB_D_P -USB_D_N
differential pair " ": +EZFET_D_P -EZFET_D_N

## Components (designator, comment, footprint, x,y, rotation, side; value= is the part's Value field where it differs from the comment)
A1 "5012" Keystone5012 244.12,2581.6 r0 top
A2 "5012" Keystone5012 127.56,2455.33 r0 top
A3 "5012" Keystone5012 325.39,2301 r0 top
A4 "5012" Keystone5012 127.56,2163.78 r0 top
C1 "C1005C0G1H330J050BA" 0402 2643.95,309 r270 top
C2 "C1005C0G1H330J050BA" 0402 2731,312 r270 top
C3 "C1005C0G1H330J050BA" 0402 2704.47,615.26 r90 top
C4 "C1005C0G1H330J050BA" 0402 2704.47,735.77 r90 top
C5 "C1005C0G1H330J050BA" 0402 2704.47,853.88 r90 top
C6 "C1005C0G1H330J050BA" 0402 2704.47,971.99 r90 top
C7 "885012105010" 0402L 110,1758.56 r90 top
C8 "885012105010" 0402L 650,2405 r270 top
C9 "885012105010" 0402L 700,2402.94 r270 top
C10 "885012105010" 0402L 750,2411.63 r270 top
C11 "885012105010" 0402L 799.6,2452 r270 top
C12 "885012105010" 0402L 1739,3413 r270 top
C13 "885012106008" FP-885012106008_0603-MFG 608,1513 r0 top
C14 "T520A106M010ATE080" 3216-18 1563.52,1933 r270 top
C15 "885012105010" 0402L 537,1957 r90 top
C16 "885012105010" 0402 490,1511 r0 top
C17 "885012105010" 0402 1463.2,1929 r270 top
C18 "885012105010" 0402 891,2366 r180 top
C19 "885012005058" FP-885012005058_0402-MFG 2059,2609 r180 top
C20 "C1005X5R1A475M050BC" 0402 1217.4,4156.75 r45 top
C21 "885012105010" 0402 1371.3,3875.7 r315 top
C22 "885012005058" FP-885012005058_0402-MFG 737,4365 r180 top
C23 "885012205061" 0402 508,4519.78 r270 top
C24 "885012005058" FP-885012005058_0402-MFG 737,4513 r180 top
C25 "885012105010" 0402 795.32,4231.57 r90 top
C26 "885012005055" 0402 1314.68,3562 r180 top
C27 "885012005055" 0402 1470.62,3306 r180 top
C28 "885012105011" 0402 1154.85,4219.19 r45 top
C29 "885012106008" FP-885012106008_0603-MFG 486.58,4153.89 r90 top
C30 "885012105011" 0402 1186.31,4187.69 r45 top
C31 "T520A106M010ATE080" 3216-18 579.08,4174.55 r90 top
C32 "885012105010" 0402 741.58,4231.57 r90 top
C33 "885012105010" 0402 679.13,4231.57 r90 top
C34 "885012105010" 0402 1097.62,3728.76 r225 top
C35 "885012105012" 0402 1238.67,4498.15 r90 top
C36 "885012105010" 0402 1281.11,4498.17 r90 top
C37 "885012205031" 0402 1325.15,4498.15 r90 top
C38 "885012106018" 0603 1245.71,4387.83 r90 top
C39 "885012205031" 0402 1342.71,4192.23 r0 top
C40 "885012105012" 0402 1189.27,4409 r90 top
C41 "885012105010" 0402L 2200,4306 r90 top
C42 "885012005055" 0402 1450.9,4232.66 r180 top
C43 "885012005055" 0402 1553.69,4232.66 r0 top
C44 "HMK107BJ104MA-T" FP-0603-L_1_6_0_1-W_0_8_0-IPC_B 2062.63,3937.5 r270 top
C45 "885012105012" 0402 1563,3936.01 r270 top
C46 "GRM21BC81E335KA73L" 0805_HV 1951.48,3878.94 r270 top
C47 "885012105011" 0402 1786,4773.03 r0 top
C48 "885012105010" 0402 1393.91,4488.31 r270 top
C49 "C2012X7R1H105K125AB" 0805_HV 3631.46,2941.69 r90 top
C50 "885012206120" FP-885012206120_0603-MFG 3627.8,2292.58 r90 top
C51 "C2012X7R1H105K125AB" 0805_HV 4059.47,2208 r180 top
C52 "885012006085" FP-885012006085_0603-MFG 4652,1758 r90 top
C53 "EMVY101ARA101MKE0S" FP-EMVY101ARA101MKE0S_RADIAL-MFG 3629,3879.72 r180 top
C54 "885012006085" FP-885012006085_0603-MFG 3066.15,4297.46 r180 bottom
C55 "885012206120" FP-885012206120_0603-MFG 3063.49,4219.07 r180 bottom
C56 "CGA6M2X7R2A105K200AA" 1210_220 4097,2099 r180 top
C57 "885012206114" 0603L 4196.61,2575 r0 top
C58 "885012206114" 0603L 4159.51,2285.44 r90 top
C59 "885012206114" 0603L 4145.19,2873.57 r90 top
C60 "885012006085" FP-885012006085_0603-MFG 4693.24,2192 r90 bottom
C61 "885012006085" FP-885012006085_0603-MFG 4645,2575.07 r0 top
C62 "885012105010" 0402L 2842.28,2521 r180 top
C63 "885012206120" FP-885012206120_0603-MFG 3535.87,2928 r270 top
C64 "885012006085" FP-885012006085_0603-MFG 4585,3630 r315 top
C65 "885012006085" FP-885012006085_0603-MFG 4691,3227 r270 bottom
C66 "885012006085" FP-885012006085_0603-MFG 4655,2679.86 r0 top
C67 "885012005080" FP-885012005080_0402-MFG 4758,1471 r270 top
C68 "885012005080" FP-885012005080_0402-MFG 4750,1156 r270 top
C69 "885012005080" FP-885012005080_0402-MFG 4756,882.18 r270 top
C70 "885012005080" FP-885012005080_0402-MFG 4757,578 r270 top
C71 "885012005080" FP-885012005080_0402-MFG 4245.03,289.38 r270 top
C72 "885012205031" 0402 429.66,2006.84 r0 top
C73 "885012205031" 0402 430,2056 r180 top
C74 "1.1 nF" FP-C0805C-DN-MFG 1458.81,2548.26 r180 top
D1 "150060RS75000" WL-SMCW_RED 455.83,4325.87 r270 top
D2 "150060VS75000" WL-SMCW_GREEN 335.39,4330.24 r270 top
D3 "MMDL770T1G" ONSC-SOD-323-2-477-02_V 1368.83,4634 r180 top
D4 "150060SS75000" 0603_A 3061.55,4602.39 r0 top
D5 "150060VS75000" WL-SMCW_GREEN 1657,3477 r90 top
D6 "150060VS75000" WL-SMCW_GREEN 230.07,1248.3 r90 top
D7 "150060SS75000" WL-SMCW_RED 3092.32,3577 r0 top
D8 "150060VS75000" WL-SMCW_GREEN 349.92,1248.34 r90 top
D9 "150060YS75000" WL-SMCW_YELLOW 475.6,1248.75 r90 top
D10 "150060VS75000" WL-SMCW_GREEN 601,1249 r90 top
D10 "150060VS75000" WL-SMCW_GREEN 601,1249 r90 top
D10 "150060YS75000" WL-SMCW_YELLOW 601,1249 r90 top
D11 "150060VS75000" WL-SMCW_GREEN 720.5,1249.5 r90 top
D11 "150060VS75000" WL-SMCW_GREEN 720.5,1249.5 r90 top
D11 "150060YS75000" WL-SMCW_YELLOW 720.5,1249.5 r90 top
D12 "150060SS75000" WL-SMCW_RED 854.91,1250.52 r90 top
D12 "150060SS75000" WL-SMCW_RED 854.91,1250.52 r90 top
D12 "150060YS75000" WL-SMCW_YELLOW 854.91,1250.52 r90 top
D13 "BZX84J-B4V7,115" FP-BZX84J-B4V7,115_SC90-MFG 2717.06,4677.68 r180 top
F1 "0463015.ER" Fuse_0463 4238,3913 r90 top
FID1 "Fiducial" Fiducial10-20 78.74,4921.26 r0 top locked
FID2 "Fiducial" Fiducial10-20 78.74,78.74 r90 top
FID3 "Fiducial" Fiducial10-20 4921.26,4921.26 r0 top locked
H1 "4822" KEYSTONE_4822 255.91,255.91 r0 bottom locked
H1_Nut "9605" Keystone_9605 255.91,255.91 r0 top locked
H2 "4822" KEYSTONE_4822 4744.09,255.91 r0 bottom locked
H2_Nut "9605" Keystone_9605 4744.09,255.91 r0 top locked
H3 "4822" KEYSTONE_4822 4744.09,4744.09 r0 bottom locked
H3_Nut "9605" Keystone_9605 4744.09,4744.09 r0 top locked
H4 "4822" KEYSTONE_4822 255.91,4744.09 r180 bottom locked
H4_Nut "9605" Keystone_9605 255.91,4744.09 r0 top locked
J1 "CMP-0075613-1" Samtec_SSQ-110-03-x-D 2916.94,568.45 r90 bottom
J2 "CMP-0075613-1" Samtec_SSQ-110-03-x-D 1216.94,568.45 r90 bottom
J3 "61301421121" Wurth_61301421121 963,3071.26 r270 top
J4 "TSM-108-01-L-DV" Samtec_TSM-108-01-x-DV 2519.26,3246.98 r0 top
J5 "PBC02SAAN" Sullins_PBC02SAAN 2874,2703.25 r0 top
J6 "PBC02SAAN" Sullins_PBC02SAAN 2251,2753 r270 top
J7 "PBC02SAAN" Sullins_PBC02SAAN 2251,2613.02 r270 top
J8 "TSM-108-01-L-DV" Samtec_TSM-108-01-x-DV 2519.59,2095 r0 top
J9 "61301421121" Wurth_61301421121 846.43,4817.4 r270 top
J10 "61301421121" Wurth_61301421121 972,3385.02 r270 top
J11 "CMP-0055311-1" Molex_1051640001 1485.86,4938.27 r180 top
J12 "691256610002" FP-691256610002_HDR2-MFG 3915,4610.24 r180 top
J13 "691250610002" FP-691250610002_CONN_TERM_BLOCK2-MFG 4754.96,3210.19 r90 top
J14 "691250610002" FP-691250610002_CONN_TERM_BLOCK2-MFG 4754.78,2179.47 r90 top
J15 "D3082-05" Harwin_D3082-05 2793.72,4842.43 r180 top
J16 "PBC02SAAN" Sullins_PBC02SAAN 3068,3278.58 r90 top
J17 "PBC02SAAN" Sullins_PBC02SAAN 3086,2700.59 r90 top
J18 "PBC02SAAN" Sullins_PBC02SAAN 3090.12,2843.7 r90 top
J19 "PBC02SAAN" Sullins_PBC02SAAN 3283.79,2944.54 r0 top
J20 "PBC02SAAN" Sullins_PBC02SAAN 3091,3118 r90 top
J21 "D3082-05" Harwin_D3082-05 139,3707 r90 top
J22 "D3082-05" Harwin_D3082-05 4295.44,2544.74 r270 top
J23 "691250610002" FP-691250610002_CONN_TERM_BLOCK2-MFG 4755,3989 r90 top
J24 "D3082-05" Harwin_D3082-05 4451,2583 r270 top
J25 "PBC02SAAN" Sullins_PBC02SAAN 2522.62,2753 r270 top
J26 "PBC02SAAN" Sullins_PBC02SAAN 2734,2702 r0 top
J27 "61300311121" WURTH_61300311121 1760,2602 r0 top
J28 "D3082-05" Harwin_D3082-05 4542,1439 r90 top
L1 "BLM18AG151BH1D" 0603 1256.1,4683.31 r270 top
L2 "BLM18AG151BH1D" 0603 1559.22,4627.72 r270 top
LBL1 "THT-14-423-10" Label_650x200 2571,3992 r0 top
LOGO1 "CAUTION HOT SURFACE" IEC_HotSurface_Small 3863,3058 r0 top
Logo2 "CE Mark" CE_Mark_5mm 2017,855.84 r180 bottom
Logo3 "Texas Instruments" TI_Stacked_Overlay_Small 3714,1305 r0 top
Logo4 "FCC disclaimer" FCC_disclaimer 8653,-1614.39 r90 bottom
Logo5 "WEEE logo" WEEE_Minimum 2036,528.08 r180 bottom
Logo6 "CAUTION.  READ USER GUIDE BEFORE USE" IEC_Caution_Small 2067.96,570.04 r0 top
LOGO7 "CAUTION HOT SURFACE" IEC_HotSurface_Small 3637,2600 r180 bottom
Q1 "BC846BLT1G" ONSC-SOT-23-3-318-08_V 2904.07,4627.5 r0 top
R1 "Resistor" 0402L 3096.08,115.69 r180 top
R2 "CRCW0603330KJNEA" 0603L 513.67,1689.83 r270 top
R3 "CRCW0603330KJNEA" 0603L 1317.1,1570.18 r180 top
R4 "CH0402-10RJFPT" FP-CH0402-10RJFPT_0402-MFG 127.47,1856.48 r180 top
R5 "Resistor" 0402L 4663,1471 r270 top
R6 "Resistor" 0402L 3094.11,821.4 r180 top
R7 "Resistor" 0402L 4705,1471 r270 top
R8 "Resistor" 0402L 4652,1156 r270 top
R9 "Resistor" 0402L 1430.72,113.72 r180 top
R10 "Resistor" 0402L 4696,1156 r270 top
R11 "Resistor" 0402L 1430.72,718.45 r180 top
R12 "Resistor" 0402L 4704,882.18 r270 top
R13 "Resistor" 0402L 4665,882.18 r270 top
R14 "Resistor" 0402L 2582.3,922.78 r0 top
R15 "Resistor" 0402L 4704,578 r270 top
R16 "Resistor" 0402L 4665,578 r270 top
R17 "Resistor" 0402L 2582.3,823.65 r0 top
R18 "Resistor" 0402L 2583.25,706.24 r0 top
R19 "CRCW060310K0FKEA" 0603 2707.15,1102 r180 top
R20 "Resistor" 0402L 1265,2904 r180 top
R21 "Resistor" 0402L 2582.3,590.26 r0 top
R22 "Resistor" 0402L 1174,2902 r0 top
R23 "Resistor" 0402L 1426,925 r180 top
R24 "Resistor" 0402L 1431.69,218.45 r180 top
R25 "Resistor" 0402L 1425,816 r180 top
R26 "Resistor" 0402L 1425.69,613.3 r180 top
R27 "Resistor" 0402L 3094.11,714.12 r180 top
R29 "CRCW040247K0JNED" 0402 887.07,2462 r180 top
R30 "Resistor" 0402L 1428,1016 r180 top
R32 "Resistor" 0402L 1430.72,316.48 r180 top
R33 "Resistor" 0402L 3094.11,519.24 r180 top
R34 "Resistor" 0402L 1430.72,420.81 r180 top
R35 "CH0402-10RJFPT" FP-CH0402-10RJFPT_0402-MFG 230.55,1856.48 r0 top
R39 "CRCW04021K00FKED" 0402L 2250,3299 r0 top
R40 "CRCW04021K00FKED" 0402L 2248.35,3196.98 r0 top
R41 "CRCW04021K00FKED" 0402L 2249.9,3097 r0 top
R42 "CRCW04021K00FKED" 0402L 2249.31,2996 r0 top
R44 "CRCW060310K0FKEA" 0603 2055.93,2760 r180 top
R49 "CRCW060310K0FKEA" 0603 2055.93,2680.83 r0 top
R54 "Resistor" 0402L 679.13,2815 r180 top
R55 "RC0402FR-07220KL" 0402 738,4461 r180 top
R56 "240k" RESC1005X40X25NL05T05 736,4622 r180 top
R57 "CRCW040247K0JNED" 0402 572,4519 r270 top
R58 "CRCW0402470RJNED" 0402 417.14,4148.71 r270 top
R59 "CRCW0402560RJNED" 0402 334.39,4150.93 r270 top
R60 "RC0402FR-07220KL" 0402 738,4418 r0 top
R61 "CRCW0402150KFKED" 0402 738,4568 r0 top
R62 "ERJ-2GE0R00X" 0402L 1081.15,4574.22 r90 top
R63 "ERJ-2GE0R00X" 0402L 1122.53,4574.22 r90 top
R64 "CRCW040210R0FKED" 0402 1196.13,3587.09 r225 top
R65 "CRCW040210R0FKED" 0402 1096.78,3587.09 r225 top
R66 "CRCW040210R0FKED" 0402 997.7,3587.15 r225 top
R67 "CRCW040210R0FKED" 0402 897.42,3587.09 r225 top
R68 "Resistor" 0402L 1482.5,4061.04 r270 top
R69 "Resistor" 0603L 1695.8,4569 r0 top
R70 "Resistor" 0603L 1697.07,4463.9 r180 top
R71 "CRCW040227R0JNED" 0402 1693.38,4163.18 r0 top
R72 "CRCW040227R0JNED" 0402 1480.94,4426.57 r270 top
R73 "CRCW040227R0JNED" 0402 1694,4226.15 r0 top
R74 "0" RESC1005X40X25NL05T05 1464,3994.83 r180 top
R75 "CRCW040227R0JNED" 0402 1529.37,4426.57 r270 top
R76 "CRCW04021K40FKED" 0402 1277.89,4042.33 r315 top
R77 "CRCW04021M00JNED" 0402 1306.35,4072.35 r135 top
R78 "CRCW040233K0JNED" 0402 1786,4836 r180 top
R79 "ERJ-2RKF3301X" 0402L 3094,3390 r0 top
R80 "ERJ-2RKF3301X" 0402L 3112,2585.99 r0 top
R81 "ERJ-2RKF3301X" 0402L 3124,2956.93 r0 top
R82 "ERJ-2RKF3301X" 0402L 3123.31,3003.4 r0 top
R83 "RC0603JR-0710KL" 0603L 3579,2794 r90 top
R84 "CRCW04020000Z0EDHP" 0402 3001,3391 r0 top
R85 "CRCW04020000Z0EDHP" 0402 3022.23,2585.99 r0 top
R86 "CRCW04020000Z0EDHP" 0402 3031,2956 r0 top
R87 "CRCW04020000Z0EDHP" 0402 3032,3003.4 r0 top
R88 "RC0603JR-0710KL" 0603L 3499,2793.22 r90 top
R89 "CRCW060386K6FKEA" 0603L 4817,1584.4 r90 top
R90 "CRCW060386K6FKEA" 0603L 4808.22,1298.49 r90 top
R91 "CRCW060386K6FKEA" 0603L 4818.48,1009.13 r90 top
R92 "CRCW060386K6FKEA" 0603L 4819.04,699 r90 top
R93 "CRCW06034K99FKEA" 0603L 4817,1471 r90 top
R94 "CRCW06034K99FKEA" 0603L 4809.14,1154.79 r90 top
R95 "CRCW06034K99FKEA" 0603L 4818.48,881.18 r90 top
R96 "CRCW06034K99FKEA" 0603L 4818,577 r90 top
R97 "CRCW040247K0JNED" 0402 3061.55,4668.92 r0 top
R98 "RT0603DRE0797K6L" 0603 4325,405.58 r90 top
R99 "RC0603JR-0710KL" 0603L 211,1343 r180 top
R100 "RC0603JR-0710KL" 0603L 211,1423 r180 top
R101 "RC0603JR-0710KL" 0603L 212,1511 r180 top
R102 "RC0603JR-0710KL" 0603L 1246.45,2550.6 r270 top
R103 "RC0603JR-0710KL" 0603L 1157,2550.56 r270 top
R104 "CRCW06034K99FKEA" 0603L 4325.24,292.18 r90 top
R105 "RC0603JR-0710KL" 0603L 97,1343 r180 top
R106 "RC0603JR-0710KL" 0603L 96,1421.84 r180 top
R107 "RC0603JR-0710KL" 0603L 98,1509 r180 top
R108 "RC0603JR-0710KL" 0603L 1246.45,2437.2 r270 top
R109 "RC0603JR-0710KL" 0603L 1157,2437.16 r270 top
R110 "RC0603FR-07560RL" 0603 1655.89,3341.12 r90 top
R111 "CMP-0025785-4" 0603L 601.14,1117.82 r90 top
R112 "CMP-0025785-4" 0603L 2963,3577 r0 top
R113 "CMP-0025785-4" 0603L 349.92,1114 r90 top
R114 "CMP-0025785-4" 0603L 229.56,1112 r90 top
R115 "CMP-0025785-4" 0603L 475.7,1113.31 r90 top
R116 "CMP-0025785-4" 0603L 721.19,1117.57 r90 top
R117 "CMP-0025785-4" 0603L 853.92,1118.19 r90 top
R118 "RC0603FR-07470RL" 0603 2706.12,4588.61 r0 top
S1 "430481025816" FP-430481025816_SMT_SW_6MM2_6MM2-MFG 1878,2367 r0 top
SH-J1 "60900213421" Wurth_60900213421 2519.26,3596.98 r180 top
SH-J2 "60900213421" Wurth_60900213421 2519.26,3495.44 r180 top
SH-J3 "60900213421" Wurth_60900213421 871.6,3385.83 r90 top
SH-J4 "60900213421" Wurth_60900213421 2519.26,3393.9 r180 top
SH-J5 "60900213421" Wurth_60900213421 5098,1707 r90 top
SH-J6 "60900213421" Wurth_60900213421 971.2,3385.83 r90 top
SH-J7 "60900213421" Wurth_60900213421 2519.26,3292.35 r180 top
SH-J8 "60900213421" Wurth_60900213421 2519.26,2429.62 r0 top
SH-J9 "60900213421" Wurth_60900213421 1070.8,3385.83 r90 top
SH-J10 "60900213421" Wurth_60900213421 2519.26,3190.81 r180 top
SH-J11 "60900213421" Wurth_60900213421 2519.26,2987.72 r180 top
SH-J12 "60900213421" Wurth_60900213421 1270,3385.83 r90 top
SH-J13 "60900213421" Wurth_60900213421 2519.26,3089.26 r180 top
SH-J14 "60900213421" Wurth_60900213421 2519.26,2886.18 r180 top
SH-J15 "60900213421" Wurth_60900213421 1170.4,3385.83 r90 top
SH-J16 "60900213421" Wurth_60900213421 2519.26,2331.71 r0 top
SH-J17 "60900213421" Wurth_60900213421 2519.26,2037.97 r0 top
SH-J18 "60900213421" Wurth_60900213421 2519.26,1744.24 r0 top
SH-J19 "60900213421" Wurth_60900213421 2519.26,2233.8 r0 top
SH-J20 "60900213421" Wurth_60900213421 2519.26,1940.06 r0 top
SH-J21 "60900213421" Wurth_60900213421 2519.26,1842.15 r0 top
SH-J22 "60900213421" Wurth_60900213421 2519.26,2135.89 r0 top
SH-J23 "60900213421" Wurth_60900213421 5098,109 r90 top
SH-J24 "60900213421" Wurth_60900213421 5098,375.33 r90 top
SH-J25 "60900213421" Wurth_60900213421 5098,641.67 r90 top
SH-J26 "60900213421" Wurth_60900213421 5098,908 r90 top
SH-J27 "60900213421" Wurth_60900213421 1711.69,2601.93 r180 top
SH-J28 "60900213421" Wurth_60900213421 2251,2753 r180 top
SH-J29 "60900213421" Wurth_60900213421 2734,2702 r90 top
SH-J30 "60900213421" Wurth_60900213421 5098,1440.67 r90 top
SH-J31 "60900213421" Wurth_60900213421 5098,1174.33 r90 top
TP1 "TP_H0.45P0.75" TP_H045P075 317.77,1761.28 r90 top
TP2 "TP_H0.45P0.75" TP_H045P075 388.67,1731.28 r90 top
TP3 "TP_H0.45P0.75" TP_H045P075 320.21,1683 r90 top
TP4 "TP_H0.45P0.75" TP_H045P075 390,1646 r90 top
TP5 "TP_H0.45P0.75" TP_H045P075 319.77,1604.33 r90 top
TP6 "TP_H0.45P0.75" TP_H045P075 1032.53,1520.65 r90 top
TP7 "TP_H0.45P0.75" TP_H045P075 1098,1456.19 r90 top
TP8 "TP_H0.45P0.75" TP_H045P075 1096,1519.67 r90 top
TP9 "TP_H0.45P0.75" TP_H045P075 1168,1518.68 r90 top
TP10 "TP_H0.45P0.75" TP_H045P075 1348.01,1793.61 r90 top
TP11 "TP_H0.45P0.75" TP_H045P075 1370.56,1858.57 r90 top
TP12 "TP_H0.45P0.75" TP_H045P075 1306.27,1862.13 r90 top
TP13 "5012" Keystone5012 564,2674 r0 top
TP14 "5012" Keystone5012 379,1883 r0 top
TP15 "5012" Keystone5012 358.01,2726.36 r0 top
TP16 "5012" Keystone5012 1017,2504.01 r0 top
TP17 "5012" Keystone5012 406.16,2578.12 r0 top
TP18 "TP_H0.45P0.75" TP_H045P075 1431.47,2041.58 r90 top
TP19 "TP_H0.45P0.75" TP_H045P075 1368,2061.53 r90 top
TP20 "TP_H0.45P0.75" TP_H045P075 1432,2105.05 r90 top
TP21 "TP_H0.45P0.75" TP_H045P075 1368,2125 r90 top
TP22 "TP_H0.45P0.75" TP_H045P075 1434,2168.53 r90 top
TP23 "TP_H0.45P0.75" TP_H045P075 1368,2200.29 r90 top
TP24 "TP_H0.45P0.75" TP_H045P075 1432,2232 r90 top
TP25 "5011" Keystone5011 91,1175 r0 top
TP26 "TP_H0.45P0.75" TP_H045P075 1366.71,2263.76 r90 top
TP27 "5010" Keystone5010 1656,3676 r0 top
TP28 "5010" Keystone5010 3298,3325 r0 top
TP29 "5011" Keystone5011 4421,4715.76 r0 top
TP30 "5010" Keystone5010 3178,3979.46 r180 top
TP31 "5015" Testpoint_Keystone_Miniature 4821.94,1777 r270 top
TP32 "5015" Testpoint_Keystone_Miniature 4824,2574.6 r90 top
TP34 "5015" Testpoint_Keystone_Miniature 4828,3597 r90 top