# Altium PCB MD041A_ASCII.PcbDoc (part 6 of 6)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 6709.84 x 5059.84 mil, 4 copper layers (Top Layer, Signal Layer 1, Signal Layer 2, Bottom Layer), stack 61.2 mil thick; 351 components, 206 nets, 927 pads, 324 vias.

## Via types
v1: diameter 19.68, hole 13.78, Top Layer to Bottom Layer, tented both sides, 174 vias
v2: diameter 34, hole 16, Top Layer to Bottom Layer, tented both sides, 114 vias
v3: diameter 19.68, hole 7.87, Top Layer to Bottom Layer, 22 vias
v4: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 6 vias
v5: diameter 141.73, hole 141.73, Top Layer to Bottom Layer, tented both sides, 6 vias
v6: diameter 201.73, hole 141.73, Top Layer to Bottom Layer, 2 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
VM: C44.1 C51.2 C53.2 C54.1 C55.1 C56.1 C57.1 C58.1 C59.1 C75.2 D4.2 F1.1 F2.1 J23.1 R97.2 R98.2 TP30.1 U5.10 U7.2 U7.11 U7.12 U7.21 | length 2800.1
  Top Layer w10: U5.10@1881.61,4004.37 C44.1@2087.54,4004.37 ; C44.1@2080.55,3995.6 C44.1@2086.99,3989.16 3115.84,3989.16 ; R97.2@3109.52,4538.92 3117.4,4531.05 D4.2@3117.4,4472.39 ; v1@5150,945 5150,421.43 R98.2@5153.35,418.07
  Top Layer w12: U7.12@4752.95,2062.99 4851.03,2062.99 v1(4851.52,2063.49) v1@4876.48,2063.49 ; v1(4877.1,2064.08) 4907.38,2064.08 4914.32,2057.14 4914.32,2056.58 4925.62,2045.28 C57.1@4926.18,2045.28 ; v1(4878.52,2038.15) 4920.04,2038.15 C57.1@4925.2,2043.31
  Top Layer w15: U7.2@4732.64,1812.5 4842.51,1812.5 v1(4881.52,1773.49)
  Top Layer w100: v1(6071.52,993.49) 6184.92,880.09 J23.1@6400.94,880.09
  Bottom Layer w10: C54.1@3114.12,4322.46 3178.85,4322.46 3183,4326.61 v1(3185.62,4326.61) 3183.77,4324.76 3183.77,4310.47 C55.1@3117.37,4244.07 C55.1@3114.5,4244.07
  other v1: 5531.5,896.65 5564.96,896.43 5598.43,896.43 5631.89,896.43 5665.35,896 5698.82,896 5732.28,896 5765.75,897 5799.21,897 5832.68,897.64 5531.5,926.18 5564.96,926 5598.43,926 5631.89,926 5665.35,927 5698.82,927 5732.28,927 5765.75,927 5799.21,927 5832.68,927.17 5151.57,946.85 6071.52,967.08 6098.52,968.15 6097.1,994.08 4881.52,1747.08 4908.52,1748.15 4907.1,1774.08 4851.52,2037.08 5001.52,2342.08 5028.52,2343.15 5001.52,2368.49 5027.1,2369.08 3606.52,3422.08 3633.52,3423.15 3665,3423.59 3692,3424.66 3606.52,3448.49 3632.1,3449.08 3665,3450 3690.58,3450.59 3462.82,3629.59 3533.69,3629.59 3604.56,3629.59 3675.42,3629.59 3746.29,3629.59 3461.84,3695.53 3532.71,3695.53 3603.57,3695.53 3674.44,3695.53 3745.3,3695.53 3461.84,3754.59 3532.71,3754.59 3603.57,3754.59 3674.44,3754.59 3745.3,3754.59 3459.87,3834.31 3672.47,3834.31 3743.34,3834.31 5236.87,3872.85 5266.45,3872.85 5236.87,3911.47 5266.45,3911.47 3459.87,3913.05 3530.74,3913.05 3601.6,3913.05 3672.47,3913.05 3743.34,3913.05 5236.87,3950.09 5266.45,3950.09 3459.87,3984.9 3530.74,3984.9 3601.6,3984.9 3672.47,3984.9 3743.34,3984.9 5236.87,3988.71 5266.45,3988.71 5235.87,4027.32 5266.87,4027.32 3462.82,4046.91 3533.69,4046.91 3604.56,4046.91 3675.42,4046.91 3746.29,4046.91 5235.87,4065.94 5266.87,4065.94 5235.87,4104.56 5266.87,4104.56 5235.87,4143.18 5265.87,4143.18 5235.87,4181.8 5265.87,4181.8 5235.87,4220.42 5265.87,4220.42
VREF/VREF2: J5.1 J6.1 J7.1 J25.2 U7.34 | length 2102.7
  Top Layer w10: J7.1@2865,2705 2865,2855 2870,2860 J25.2@2995,2860 3040.35,2905.35 3354.65,2905.35 3403.46,2856.54 3461.35,2856.54 4280.39,2037.5 U7.34@4437.36,2037.5
VSEN_AOUT1: C67.1 R5.1 R7.1 R89.1 R93.2 | length 273.9
  Top Layer w10: R5.1@6320.28,3523.22 6320.51,3523.44 6379.28,3523.44 R7.1@6379.5,3523.67 6380.1,3523.06 6443.31,3523.06 6443.91,3522.46 6443.91,3520.63 6450.18,3514.36 6452.01,3514.36 6459.02,3507.35 R93.2@6527.91,3507.35 R89.1@6527.91,3449.07
VSEN_AOUT2: C68.1 R8.1 R10.1 R90.1 R94.2 | length 283
  Top Layer w10: R8.1@6327.46,3821.98 R10.1@6380.5,3821.98 6382.98,3824.46 6447.5,3824.46 6519.14,3824.46 R94.2@6520.05,3823.56 6519.12,3822.63 R90.1@6519.12,3734.97
VSEN_BOUT1: C69.1 R12.1 R13.1 R91.1 R95.2 | length 279.5
  Top Layer w10: R13.1@6328.91,4105.67 R12.1@6377.5,4105.67 6380.67,4108.84 6440.8,4108.84 6475.97,4108.84 6487.64,4097.17 R95.2@6529.39,4097.17 R91.1@6529.39,4024.33
VSEN_BOUT2: C70.1 R15.1 R16.1 R92.1 R96.2 | length 264.5
  Top Layer w10: R16.1@6337.15,4414.35 6340.97,4410.54 R15.1@6384.15,4410.54 6390.36,4404.33 6449.75,4404.33 6452.73,4401.35 R96.2@6528.91,4401.35 6529.95,4400.3 R92.1@6529.95,4334.46
VSEN_VM: C71.1 J1.3 R98.1 R104.2 TP37.1 U1.1 | length 6269.5
  Top Layer w10: v2(1120,1910) 1186.22,1976.22 U1.1@1186.22,2084.13 ; J1.3@2991.3,243.45 3047.85,300 3468.79,300 TP37.1@3534.79,366 3534.79,271.69 3668.38,138.1 4798.1,138.1 4945,285 5045.89,285 5050,280.89 5050.89,280 5085,280 5105.74,300.74 R104.2@5153.59,300.74 ; R104.2@5153.35,300.98 R98.1@5153.35,359.02
  Signal Layer 2 w10: v2(1120,1910) 1120,1795 1040,1715 1040,433.39 1185.95,287.43 1186,287.48 1322.96,287.48 1410.38,200.06 2909.27,200.06 2945.78,236.58 2984.43,236.58 J1.3@2991.3,243.45
pads on no net: FID1.1 FID2.1 FID3.1 FID4.1 H1.0 H2.0 H3.0 H4.0 H5.0 H6.0 J1.2 J1.5 J1.7 J1.11 J1.17 J1.19 J2.6 J2.8 J2.9 J2.10 J2.11 J2.15 J2.16 J2.17 J2.19 J9.6 J9.10 J9.12 J9.13 J9.14 J10.11 J10.12 J11.4 LBL1.0 S1.2 SH-J1.0 SH-J2.0 SH-J3.0 SH-J4.0 SH-J5.0 SH-J6.0 SH-J7.0 SH-J8.0 SH-J9.0 SH-J10.0 SH-J11.0 SH-J12.0 SH-J13.0 SH-J14.0 SH-J15.0 SH-J16.0 SH-J17.0 SH-J18.0 SH-J19.0 SH-J20.0 SH-J21.0 SH-J22.0 SH-J23.0 SH-J24.0 SH-J25.0 SH-J26.0 SH-J27.0 SH-J28.0 SH-J29.0 SH-J30.0 SH-J31.0 SH-J32.0 SH-J33.0 SH-J34.0 SH-J35.0 U1.28 U1.30 U1.47 U1.48 U1.49 U1.77 U1.78 U1.79 U1.80 U1.81 U1.82 U1.86 U2.3 U2.4 U2.5 U2.6 U2.7 U2.8 U2.10 U2.12 U2.13 U2.18 U2.19 U2.22 U2.23 U2.24 U2.25 U2.26 U2.27 U2.28 U2.29 U2.30 U2.31 U2.32 U2.33 U2.34 U2.35 U2.36 U2.41 U2.42 U2.45 U2.46 U2.47 U2.48 U3.2 U3.6 U3.7 U4.2 U4.3 U4.6 U4.8 U4.9 U4.10 U4.11 U4.12 U4.13 U4.14 U4.19 U4.22 U4.23 U4.24 U4.27 U4.28 U5.3 U5.6 U5.9 U6.5
copper on no net:
  other v5: 6410,250 305,260 4580,320 4630,3835 285,4780 6415,4785

## Polygon pours and split planes (outlines as drawn)
GND on Top Layer "TOP_LAYER_GND_P013" (solid, pour order 13): 0,5060 6709.65,5060 6709.65,0 0,0
VM on Top Layer "TOP_LAYER_VM_P000" (solid, pour order 0): 5320,3280 3630,3280 3085,3825 3085,4745 5320,4745
VM on Top Layer "TOP_LAYER_VM_P003" (solid, pour order 3): 5165,2450 4845,2450 4845,2335 4810,2300 4730,2300 4730,2275 5165,2275
BOUT1/OUT3 on Top Layer "TOP_LAYER_BOUT1/OUT3_P007" (solid, pour order 7): 4715,1920 4715,1861.72 5520,1861.72 6210,1310 6710,1310 6710,1775 6565,1920
AOUT2/OUT2 on Top Layer "TOP_LAYER_AOUT2/OUT2_P005" (solid, pour order 5): 4770,2170 4770,2105 6020,2105 6285,2370 6450,2370 6450,2360 6505,2305 6705,2305 6710.13,2818.09 6425.83,2818.09 5777.74,2170
EZFET_USB_Shield on Top Layer "TOP_LAYER_EZFET_USB_SHIELD_P001" (solid, pour order 1): 1270,5035 1270,4845 1345,4770 1700,4770 1745.98,4815.98 1745.98,5034.02 1745,5035
AOUT1/OUT1 on Top Layer "TOP_LAYER_AOUT1/OUT1_P006" (solid, pour order 6): 6391.91,2818.09 6412.62,2838.81 6705,2838.81 6705,3095 6115,3095 5500,2480 5270,2480 5084.06,2294.06 4884.06,2294.06 4835,2245 4785,2245 4785,2180 5753.82,2180
VM on Top Layer "TOP_LAYER_VM_P014" (solid, pour order 14): 4920,2075 4920,2025 4730,2025 4730,2075
VM on Top Layer "TOP_LAYER_VM_P002" (solid, pour order 2): 4730,1825 4730,1800 4815,1800 4835,1715 5000,1715 5000,1825
BOUT2/OUT4 on Top Layer "TOP_LAYER_BOUT2/OUT4_P004" (solid, pour order 4): 4725,1994.98 4725,1930 6185,1930 6340,1775 6710,1775 6705,1780 6705,2305 6395,2305 6084.98,1994.98
VM on Top Layer "TOP_LAYER_VM_P008" (solid, pour order 8): 4825,1630 5560,1630 6227.5,962.5 6125,860 4825,860
GND on Signal Layer 2 "SIGNAL_LAYER_2_GND_P016" (solid, pour order 16): 2.01,5060 6709.65,5060 6709.65,0 0,0
VM on Signal Layer 2 "SIGNAL_LAYER_2_VM_P010" (solid, pour order 10): 5320,3480 5320,4235 3425,4235 3425,3480 4825,2080 4825,860 6125,860 6125,1260 5320,2065
EZFET_VBUS on Signal Layer 2 "SIGNAL_LAYER_2_EZFET_VBUS_P011" (solid, pour order 11): 1218.99,5035 1220.4,5033.59 1220.4,4480.6 1845,4480.6 1845,5035
GND on Bottom Layer "BOTTOM_LAYER_GND_P017" (solid, pour order 17): 2.01,5060 6709.65,5060 6709.65,0 0,0
EZFET_USB_Shield on Bottom Layer "BOTTOM_LAYER_EZFET_USB_SHIELD_P012" (solid, pour order 12): 1265,5035 1265,4840 1315,4790 1735,4790 1785,4840 1785,5035
GND on Signal Layer 1 "SIGNAL_LAYER_1_GND_P015" (solid, pour order 15): 2.01,5060 6709.65,5060 6709.65,0 0,0

## Keep-outs
Keep-Out Layer:
  circle w10: c6415,4785 r118.11
  circle w10: c285,4780 r118.11
  circle w10: c4630,3835 r118.11
  circle w10: c305,260 r118.11
  circle w10: c6410,250 r118.11
  circle w10: c4580,320 r118.11
  text ".Layer_Name" at 577,-858.49 h60

## Other copper
Top Layer:
  text ".Layer_Name" at 577,-858.49 h60
Bottom Layer:
  text ".Layer_Name" at 577,-858.49 h60

## Silkscreen, mask and mechanical layers (free items; w line width, h text height)
Top Overlay:
  circle w19.68: c1248.41,4933.75 r5.85
  circle w19.68: c1372.43,3498.71 r5.85
  lines w6: 116.49,527.5 881.79,527.5 ; 116.49,771.5 881.79,771.5 ; 116.49,1024.04 881.79,1024.04 ; 117.49,898.5 881.79,898.5 ; 118.49,647.5 881.79,647.5 ; 213.39,418.02 213.39,1126.51 ; 446.85,413.51 446.85,1125.51 ; 663.85,418.02 663.85,1126.51
  lines w7.87: 935,15 935,995 ; 1690,1560 3235,1560 3235,15 ; 4390,1120 4785,1120 4785,1515 4390,1515 4390,1120 ; 4390,2570 4785,2570 4785,2960 4390,2960 4390,2570
  lines w10: 1395.15,2771.22 1395.15,2926.73 1409.92,2941.49 1429.6,2941.49 ; 1223.12,4945.75 1122.26,4945.75 1122.26,4845 1223.12,4845 1223.12,4945.75 ; 1223.12,4945.75 521.26,4945.75 521.26,4744.25 1223.12,4744.25 1223.12,4945.75 ; 1347.14,3510.71 1246.28,3510.71 1246.28,3409.96 1347.14,3409.96 1347.14,3510.71 ; 1347.14,3510.71 645.28,3510.71 645.28,3309.21 1347.14,3309.21 1347.14,3510.71 ; 115.61,417.92 115.61,1129.92 880.91,1129.92 880.91,417.92 115.61,417.92
  text "For EZFET-LITE Flashing Only" at 622.05,4966.54 h39.37
  text "GND" at 4563.98,4887.8 h100
  text "VIN" at 3537.4,4886.59 h100.12
  text "Board rated for" at 5540.05,4864.11 h90
  text "40 A peak current" at 5489.17,4770.91 h90
  text "GND" at 2724.41,4750.98 h60
  text "10 A RMS/OUTx at 25°C" at 5364.17,4665.37 h90
  text "4.5V - 65V" at 3300.2,4649.62 h90
  text "VIN" at 3146.65,4447.64 h60
  text "1" at 894.35,4272.8 h23.62
  text "'.PRJ_Number'.PCB_Rev" at 2502.95,4144.69 h108.27
  text "GND" at 244.09,3687.01 h60 r90
  text "VM" at 3488.19,3675.2 h100
  text "nSLEEP" at 2705,3645 h50
  text "CAUTION - HEATSINK CAN BE HOT" at 4152.69,3618.24 h40
  text "ENABLE/IN1" at 2705,3550 h50
  text "DIR/IN2" at 2705,3445 h50
  text "STEP/IN3/RSVD" at 2705,3345 h50
  text "CAUTION - DO NOT TOUCH - HEATSINK CAN BE HOT" at 5330.87,3304.96 h45 r270
  text "SCLK/M1/IN4/RSVD" at 2700,3245 h50
  text "OUT1" at 6626.24,3162.45 h39.37 r90
  text "SDI/DECAY0/EN1/DECAY" at 2700,3145 h50
  text "AOUT1" at 6471.51,3144.41 h39.37 r90
  text "SDO/DECAY1/EN2/RSVD" at 2705,3050 h50
  text "3V3" at 1108.27,3019.69 h60
  text "RSVD/TOFF/EN3" at 2705,2945 h50
  text "Torque Count" at 1432.24,2927.86 h40
  text "ID2" at 278.54,2674.21 h60
  text "ID3" at 402.56,2672.24 h60
  text "ID1" at 144.68,2670.28 h60
  text "PUSH" at 1873.03,2581.69 h40
  text "RST" at 1675.33,2577.84 h40
  text "M0/nSCS/" at 2696.21,2504.84 h45
  text "VREF1/EN4" at 2689.21,2468.23 h45
  text "DVDD" at 3572.16,2415.86 h80
  text "IPROPI4" at 3375,2397.21 h45
  text "MODE2/IPROPI4" at 2689.21,2386.14 h45
  text "OUT2" at 6630.91,2361.3 h39.37 r90
  text "AOUT2" at 6471.51,2338.49 h39.37 r90
  text "RSVD/IPROPI3/ / IPROPI2/IPROPI" at 2682.09,2271.65 h45
  text "IPROPI3" at 3375,2212.64 h45
  text "RSVD/IPROPI2/ / IPROPI1/IPROPI" at 2687.44,2164.74 h45
  text "OUT4" at 6629.88,2135.14 h39.37 r90
  text "." at 1182.09,2133.86 h60 r270
  text "BOUT2" at 6474.53,2108.56 h39.37 r90
  text "RSVD/IPROPI1" at 2687.44,2064.74 h45
  text "MODE/MODE1" at 2689.21,1985 h45
  text "nHOME/OCPM" at 2689.21,1884.17 h45
  text "IPROPI2" at 3375,1821.85 h45
  text "nFAULT" at 2689.21,1777.21 h60
  text "nFAULT" at 3098.55,1711.74 h40
  text "IPROPI1" at 3375,1618.11 h45
  text "ID5" at 1585.63,1515.75 h60
  text "ID4" at 1583.66,1421.26 h60
  text "C2000 connector" at 1975,1420 h108.27
  text "GND" at 146.65,1372.05 h100
  text "OUT3" at 6640.33,1343.14 h39.37 r90
  text "GND" at 3448.94,1333.79 h40
  text "BOUT1" at 6479.91,1328.81 h39.37 r90
  text "GND" at 6355.17,1282.62 h45 r90
  text "LAUNCHXL-F280025C" at 1850,1275 h108.27
  text "LED" at 128.94,1151.97 h45
  text "DRV84x2" at 241.85,1152.51 h45
  text "DRV82x2" at 466.41,1152.51 h45
  text "DRV89x2" at 678.85,1152.51 h45
  text "MCU_STATUS" at 678.85,1067.51 h30
  text "D6" at 140.75,1065.94 h40
  text "MCU_STATUS" at 231.85,1066.51 h30
  text "MCU_STATUS" at 466.41,1066.51 h30
  text "D8" at 140.75,955.41 h40
  text "GUI_STATUS" at 678.85,955.51 h30
  text "GUI_STATUS" at 231.85,953.51 h30
  text "GUI_STATUS" at 466.41,953.51 h30
  text "SINGLE" at 466.41,824.51 h40
  text "D9" at 140.75,823.82 h40
  text "DRV_ENABLE" at 231.85,823.51 h30
  text "EN1" at 678.85,823.2 h40
  text "D10" at 140.75,699.3 h40
  text "EN2" at 678.85,697.11 h40
  text "DUAL" at 466.41,694.22 h40
  text "ACCEL/DECEL" at 231.85,689.56 h30
  text "VM" at 6358.13,631.05 h45 r90
  text "D11" at 140.75,575.51 h40
  text "NA" at 466.41,573.5 h40
  text "EN3" at 678.85,573.5 h40
  text "INDEXER HOME" at 231.85,570.2 h30
  text "D12" at 140.75,456.36 h40
  text "EN4" at 680.01,456.36 h40
  text "NA" at 231.85,455.75 h40
  text "NA" at 466.41,455.75 h40
  text "GND" at 5631.89,226.76 h60
  text "GND" at 972.35,101 h72.83
  text "3V3" at 3074.8,70.87 h72.83
  text ".Layer_Name" at 577,-858.49 h60
Bottom Overlay:
  text ".Layer_Name" at 577,-858.49 h60
Top Paste:
  text ".Layer_Name" at 577,-858.49 h60
Bottom Paste:
  text ".Layer_Name" at 577,-858.49 h60
Top Solder:
  text ".Layer_Name" at 577,-858.49 h60
  text ".Layer_Name" at 577,-858.49 h60
Bottom Solder:
  text ".Layer_Name" at 577,-858.49 h60
Drill Guide:
  text ".Layer_Name" at 577,-858.49 h60
M1 Board Outline:
  circle w10: c305,260 r70.87
  circle w10: c285,4780 r70.87
  circle w10: c6415,4785 r70.87
  circle w10: c4630,3835 r70.87
  circle w10: c6410,250 r70.87
  circle w10: c4580,320 r70.87
  lines w10: 0,5060 6710.91,5060 ; 0,0 6709.65,0 6709.65,5062.01 0,5062.01 0,0
  text ".Layer_Name" at 577,-858.49 h60
M2 Board Dimensions:
  rectangle: 125,-400 500,-275
  rectangle: 0,-275 125,-150
  lines w7: 0,-275 1000,-275 ; 125,-400 125,-150 ; 250,-400 250,-150 ; 500,-400 500,-150 ; 750,-400 750,-150 ; 0,-400 0,-150 1000,-150 1000,-400 0,-400
  text ".Layer_Name" at 577,-858.49 h60
M3 3D STEP Top:
  text ".Layer_Name" at 577,-858.49 h60
M4 3D STEP Bottom:
  text ".Layer_Name" at 577,-858.49 h60
M5 Assembly Top:
  lines w10: -292,-930.17 6308,-930.17 ; -292,-726.83 6310,-726.83 ; -292,-523.5 -292,-1133.5 3713,-1133.5 6310,-1133.5 6310,-523.5 -291.5,-523.5 -291.5,-1133.5 1284,-1133.5 ; 2173,-1133.5 2173,-523.5 ; 3440,-726.83 3440,-523.5 ; 4280,-726.83 4280,-523.5 ; 4902,-1140 4902,-937.17
  text "COMPONENTS MARKED 'DNP' SHOULD NOT BE POPULATED." at 1153.5,-318.5 h60
  text "ASSEMBLY VARIANT:" at 1153,-434 h60
  text ".VariantName" at 2189,-434 h60
  text "PCB VIEWED FROM TOP SIDE" at -228.5,-655.67 h60
  text "BOARD #:" at 2248,-655.67 h60
  text ".PRJ_Number" at 2793.5,-655.67 h60
  text "REV:" at 3638,-655.67 h60
  text ".PCB_Rev" at 3929.5,-655.67 h60
  text "SVN REV:" at 4476,-655.67 h60
  text ".VersionControl_RevNumber" at 4982,-655.67 h60
  text "PLOT NAME =" at -228.5,-1064.34 h60
  text ".plot_File_Name" at 577,-1064.34 h60
  text "GENERATED    :" at 2250,-1064.34 h60
  text ".Print_Date" at 3119.5,-1064.34 h60
  text ".Print_Time" at 3848.5,-1064.34 h60
  text "TEXAS INSTRUMENTS" at 5113,-1064.34 h60
M6 Assembly Bottom:
  lines w10: -292.5,-727.33 6309.5,-727.33 ; -290.5,-930.67 6309.5,-930.67 ; 1115.5,-1140.5 1115.5,-937.67 ; 1737.5,-727.33 1737.5,-524 ; 2577.5,-727.33 2577.5,-524 ; 3844.5,-1134 3844.5,-524 ; 4733.5,-1134 6309,-1134 6309,-524 -292.5,-524 -292.5,-1134 2304.5,-1134 6309.5,-1134 6309.5,-524
  text "COMPONENTS MARKED 'DNP' SHOULD NOT BE POPULATED." at 6102,-318 h60
  text ".VariantName" at 5058,-434 h60
  text "ASSEMBLY VARIANT:" at 6097,-434 h60
  text ".VersionControl_RevNumber" at 1035.5,-656.17 h60
  text "SVN REV:" at 1541.5,-656.17 h60
  text ".PCB_Rev" at 2088,-656.17 h60
  text "REV:" at 2379.5,-656.17 h60
  text ".PRJ_Number" at 3224,-656.17 h60
  text "BOARD #:" at 3769.5,-656.17 h60
  text "PCB VIEWED FROM BOTTOM SIDE" at 6246,-656.17 h60
  text "TEXAS INSTRUMENTS" at 904.5,-1064.84 h60
  text ".Print_Time" at 2169,-1064.84 h60
  text ".Print_Date" at 2898,-1064.84 h60
  text "GENERATED    :" at 3767.5,-1064.84 h60
  text ".plot_File_Name" at 5440.5,-1064.84 h60
  text "PLOT NAME =" at 6246,-1064.84 h60
M9 Title Sheet:
  lines w10: -593,2316.39 -293,2316.39 ; -593,6066.39 -293,6066.39 ; -593,9816.39 -293,9816.39 ; 2742,-1433.61 2742,-1133.61 ; 2742,13266.39 2742,13566.39 ; 6072,-1433.61 6072,-1133.61 ; 6072,13266.39 6072,13566.39 ; 9407,-1433.61 9407,-1133.61 ; 9407,13266.39 9407,13566.39 ; 11120.5,-1142.61 11120.5,-532.61 16103,-532.61 ; 12737,-1433.61 12737,-1133.61 ; 12737,13266.39 12737,13566.39 ; 16072,-1433.61 16072,-1133.61 ; 16072,13266.39 16072,13566.39 ; 16103,-1142.61 16103,-532.61 ; 16103,-832.61 19103,-832.61 ; 16103,-232.61 19103,-232.61 ; 16104,361.39 19104,361.39 ; 17608,-1132.61 17608,-532.61 ; 19103,-532.61 16103,-532.61 ; 19103,67.39 16103,67.39 ; 19107,2316.39 19407,2316.39 ; 19107,6066.39 19407,6066.39 ; 19107,9816.39 19407,9816.39 ; 19108,861.89 16104,861.89 16103,861.89 16103,361.39 16103,67.39 ; 16103,-532.61 16103,67.39 ; -593,-1433.61 -593,13566.39 19407,13566.39 19407,-1433.61 -593,-1433.61 ; -293,-1133.61 -293,13266.39 19107,13266.39 19107,-1133.61 -293,-1133.61
  text "1" at 1058.34,13381.39 h70
  text "2" at 4384,13381.39 h70
  text "3" at 7714,13381.39 h70
  text "4" at 11049,13381.39 h70
  text "5" at 14374,13381.39 h70
  text "6" at 17709,13381.39 h70
  text "A" at -463,11603.39 h70
  text "A" at 19237,11603.39 h70
  text "B" at -463,7853.39 h70
  text "B" at 19237,7853.39 h70
  text "C" at -463,4103.39 h70
  text "C" at 19237,4103.39 h70
  text "D" at -463,353.39 h70
  text "D" at 19237,353.39 h70
  text "PROJECT TITLE:" at 16143,268.39 h45
  text ".PRJ_Title" at 16193,135.06 h70
  text "DESIGNED FOR:" at 16143,-32.61 h45
  text ".PRJ_Customer" at 16193,-172.61 h70
  text "FILE NAME:" at 16143,-332.61 h45
  text ".PCB_File_Name_No_Path" at 16193,-452.61 h70
  text "Texas Instruments (TI) and/or its licensors do not warrant the accuracy or completeness of this specification" at 11173.5,-614.45 h45
  text "ENGINEER:" at 16143,-622.61 h45
  text "LAYOUT BY:" at 17648,-622.61 h45
  text "or any information contained therein. TI and/or its licensors do not warrant that this design will meet" at 11128.51,-727.11 h45
  text ".PRJ_Engineer" at 16193,-777.6 h70
  text ".PCB_Layout" at 17698.5,-777.6 h70
  text "the specifications, will be suitable for your application or fit for any particular purpose, or will operate in" at 11128.51,-839.78 h45
  text ".Layer_Name" at 577,-858.49 h60
  text "ALTIUM DESIGNER VERSION:" at 17648,-932.61 h45
  text "an implementation. TI and/or its licensors do not warrant that the design is production worthy. You should" at 11128.51,-952.44 h45
  text "completely validate and test your design implementation to confirm the system functionality for your application." at 11173.5,-1065.11 h45
  text ".print_Scale" at 16193,-1065.94 h70
  text ".Application_BuildNumber" at 17698.5,-1065.94 h70
  text "1" at 1058.34,-1318.61 h70
  text "2" at 4384,-1318.61 h70
  text "3" at 7714,-1318.61 h70
  text "4" at 11049,-1318.61 h70
  text "5" at 14374,-1318.61 h70
  text "6" at 17709,-1318.61 h70
M10 Fab Notes:
  drawing of 189 lines, arcs and shapes, not listed
  text "DESIGN INFORMATION" at 17178.02,6365.17 h60
  text "MIN. TRACK WIDTH:" at 16533.46,6233.05 h60
  text "8" at 17629.7,6233.05 h60
  text "MIL" at 17784.46,6233.05 h60
  text "MIN. CLEARANCE:" at 16533.46,6108.92 h60
  text "MM" at 17784.46,6108.92 h60
  text "0.2" at 17588.58,6106.3 h60
  text "MIN. VIA PAD SIZE:" at 16533.46,5984.8 h60
  text "24" at 17599.71,5984.8 h60
  text "MIL" at 17784.46,5984.8 h60
  text "0.05mm (2MIL)" at 17228.46,5854.9 h60
  text "MINIMUM ANNULAR RING" at 16204.23,5846.67 h60
  text "EXTERNAL" at 17936.46,5846.67 h60
  text "PER" at 16404.23,5736.55 h60
  text "IPC-D-275 CLASS 2 LEVEL C" at 16624.23,5736.54 h60
  text "MIL, HOLES" at 18112.46,5636.07 h60
  text "+/-" at 17720,5627.48 h60
  text "+/-" at 18574,5627.48 h60
  text "REGISTRATION TOLERANCES:" at 16204.23,5626.42 h60
  text "METAL" at 17404,5626.42 h60
  text "5" at 17980.2,5626.42 h60
  text "3" at 18813.2,5626.42 h60
  text "MIL" at 18929.46,5626.42 h60
  text "HOLE SIZE TOLERANCE (UNLESS OTHERWISE SPECIFIED):" at 16204.23,5528.1 h60
  text "+/-" at 18574,5525.23 h60
  text "3" at 18813.2,5524.17 h60
  text "MIL" at 18929.46,5524.17 h60
  text "MATERIAL:" at 16129.46,5386.52 h60
  text "FR-4 High Tg" at 17115.9,5258 h60
  text "X" at 16971.46,5250.01 h60
  text "FR-408" at 16550.46,5245.49 h60
  text "OTHER" at 18038.46,5245.49 h60
  text "62 MIL (1.6mm) +/-10%" at 16870.56,5102.46 h60
  text "X" at 16750.46,5100.01 h60
  text "THICKNESS:" at 16204.23,5094.24 h60
  text "OTHER" at 18155.46,5094.24 h60
  text "TOLERANCE:" at 16204.23,4955.92 h60
  text "X" at 17052.46,4955.92 h60
  text "ANSI IPC-6012 TYPE 3 CLASS 2" at 17230.48,4955.92 h60
  text "OTHER +/-" at 17230.46,4811.73 h60
  text "BOW & TWIST:" at 16204.23,4666.54 h60
  text "X" at 17052.46,4666.54 h60
  text "ANSI IPC-6012 TYPE 3 CLASS 2" at 17230.48,4666.54 h60
  text "OTHER +/-" at 17230.46,4519.85 h60
  text "DRILLING:" at 16129.46,4389.23 h60
  text "NC_DRILL FILES" at 17890.46,4284.04 h60
  text "REFERENCE:" at 16204.23,4280.1 h60
  text "X" at 16861.46,4280.01 h60
  text "AS SHOWN" at 17039.46,4280.1 h60
  text "X" at 17762.46,4280.1 h60
  text "OTHER" at 18188.46,4137.85 h60
  text "PTH COPPER THICKNESS:" at 16203.91,4134.32 h60
  text "X" at 17343.14,4134.32 h60
  text "20-30 um" at 17471.14,4134.32 h60
  text "BOARD FINISH:" at 16129.46,3986.73 h60
  text "SILKSCREEN:" at 16284.68,3876.6 h60
  text "X" at 17242.46,3876.6 h60
  text "TOP" at 17359.46,3876.6 h60
  text "X" at 17752.46,3876.6 h60
  text "BOTTOM" at 17870.46,3876.6 h60
  text "SILKSCREEN COLOR:" at 16284.68,3721.41 h60
  text "X" at 17241.46,3721.41 h60
  text "WHITE" at 17359.46,3721.41 h60
  text "OTHER" at 17870.46,3721.41 h60
  text "X" at 17372.46,3577.96 h60
  text "GREEN" at 17490.46,3577.96 h60
  text "OTHER" at 18108.46,3577.96 h60
  text "SOLDER RESIST COLOR:" at 16284.68,3571.1 h60
  text "X" at 17372.46,3423.71 h60
  text "MATTE" at 17490.46,3423.71 h60
  text "SEMI-GLOSS" at 18108,3423.07 h60
  text "IMMERSION GOLD (ENIG)" at 17190.46,3250.94 h60
  text "ENEPIG" at 18528,3243.72 h60
  text "SURFACE FINISH:" at 16129.46,3242.72 h60
  text "X" at 17012.46,3242.72 h60
  text "IMM. TIN/SILVER OR EQUIV" at 16459,3105.4 h60
  text "OTHER" at 17890.46,3101.47 h60
  text "ARRAY/PANEL:" at 16129.46,2946.09 h60
  text "CUT AND TRIM PER M1 BOARD OUTLINE" at 17190.46,2937.87 h60
  text "N.C. ROUTE" at 17190.46,2801.9 h60
  text "X" at 17878.46,2801.9 h60
  text "V. SCORE" at 18056.46,2801.9 h60
  text "CERTIFICATION:" at 16129.46,2672.77 h60
  text "MATERIALS AND WORKMANSHIP FOR ALL PCBS" at 16854.46,2672.77 h60
  text "TO MEET OR EXCEED THE REQUIREMENTS OF:" at 16854.46,2578.71 h60
  text "X" at 16491.97,2450.08 h60
  text "ANSI IPC-A-600F CLASS ->" at 16619.96,2450.08 h60
  text "X" at 18267.97,2450.08 h60
  text "2" at 18377.96,2450.08 h60
  text "1" at 18062.96,2448.58 h60
  text "3" at 18731.96,2448.58 h60
  text "X" at 17303.97,2302.39 h60
  text "RoHS" at 17431.96,2302.39 h60
  text "OTHER" at 18076.36,2302.39 h60
  text "PER ORDER" at 18473.42,2302.39 h60
  text "ALL BOARDS MUST MEET OR EXCEED UL94-V0 REQUIREMENTS." at 16157,2148.57 h60
  text "PCB MUST BEAR THE UL94V-0 UL REGISTERED MATERIAL ID NUMBER" at 16157,2032.5 h60
  text "ADDITIONAL REQUIREMENTS:" at 16129.46,1863.08 h60
  text "MICROSECTION:" at 16204.23,1755.95 h60
  text "YES" at 17109.96,1755.95 h60
  text "REQUIRED" at 17971.46,1611.62 h60
  text "BARE BOARD ELEC. TEST:" at 16204.23,1608.76 h60
  text "NONE" at 17509.96,1608.76 h60
  text "X" at 17853.46,1608.76 h60
  text "PER ORDER" at 18563.46,1608.76 h60
  text "XX MIL VIAS REQUIRE NON-CONDUCTIVE FILL AND PLANARIZE" at 16372.38,1403.82 h59
  text "XX MIL VIAS REQUIRE CONDUCTIVE FILL AND PLANARIZE" at 16380.38,1299.84 h60
  text "OUTER XX MIL TRACES REQUIRE 50 OHM SINGLE-ENDED IMPEDANCE" at 16379.39,1136.46 h58
  text "LAYER 2 & 3 (INNER LAYERS) XX MIL WIDE, XX MIL SPACE / TRACES REQUIRE 100 OHM DIFFERENTIAL IMPEDANCE" at 16371.39,900.74 h60
  text ".Layer_Name" at 577,-858.49 h60
M11 Gerber Information:
  lines w10: -292,-930.17 6308,-930.17 ; -292,-726.83 6310,-726.83 ; -292,-523.5 -292,-1133.5 3713,-1133.5 6310,-1133.5 6310,-523.5 -291.5,-523.5 -291.5,-1133.5 1284,-1133.5 ; 2173,-1133.5 2173,-523.5 ; 3440,-726.83 3440,-523.5 ; 4280,-726.83 4280,-523.5 ; 4902,-1140 4902,-937.17
  text "ALL ARTWORK VIEWED FROM TOP SIDE" at -228.5,-655.67 h60
  text "BOARD #:" at 2248,-655.67 h60
  text ".PRJ_Number" at 2793.5,-655.67 h60
  text "REV:" at 3638,-655.67 h60
  text ".PCB_Rev" at 3929.5,-655.67 h60
  text "SVN REV:" at 4476,-655.67 h60
  text ".VersionControl_RevNumber" at 4982,-655.67 h60
  text "LAYER NAME =" at -228.5,-858.49 h60
  text "PLOT NAME =" at -228.5,-1064.34 h60
  text ".plot_File_Name" at 577,-1064.34 h60
  text "GENERATED    :" at 2250,-1064.34 h60
  text ".Print_Date" at 3119.5,-1064.34 h60
  text ".Print_Time" at 3848.5,-1064.34 h60
  text "TEXAS INSTRUMENTS" at 5113,-1064.34 h60
M12 Stackup:
  drawing of 295 lines, arcs and shapes, not listed
  text "Layer" at 14605.06,13091.48 h60
  text "Name" at 15014.97,13091.48 h60
  text "Material" at 15954.71,13091.48 h60
  text "Thickness" at 16814.48,13091.48 h60
  text "Constant" at 17464.32,13091.48 h60
  text "Board Layer Stack" at 18034.18,13091.48 h60
  text "Top Overlay" at 15014.97,12971.48 h60
  text "Top Solder" at 15014.97,12851.48 h60
  text "Solder Resist" at 15954.71,12851.48 h60
  text "0.40mil" at 16814.48,12851.48 h60
  text "3.5" at 17464.32,12851.48 h60
  text "1" at 14605.06,12731.48 h60
  text "Top Layer" at 15014.97,12731.48 h60
  text "2.80mil" at 16814.48,12731.48 h60
  text "Dielectric 1" at 15014.97,12611.48 h60
  text "FR4 370" at 15954.71,12611.48 h60
  text "11.40mil" at 16814.48,12611.48 h60
  text "4.2" at 17464.32,12611.48 h60
  text "2" at 14605.06,12491.48 h60
  text "Signal Layer 1" at 15014.97,12491.48 h60
  text "1.40mil" at 16814.48,12491.48 h60
  text "Dielectric 2" at 15014.97,12371.48 h60
  text "FR4 370" at 15954.71,12371.48 h60
  text "30.00mil" at 16814.48,12371.48 h60
  text "4.2" at 17464.32,12371.48 h60
  text "3" at 14605.06,12251.48 h60
  text "Signal Layer 2" at 15014.97,12251.48 h60
  text "1.40mil" at 16814.48,12251.48 h60
  text "Dielectric 3" at 15014.97,12131.48 h60
  text "FR4 370" at 15954.71,12131.48 h60
  text "11.40mil" at 16814.48,12131.48 h60
  text "4.2" at 17464.32,12131.48 h60
  text "4" at 14605.06,12011.48 h60
  text "Bottom Layer" at 15014.97,12011.48 h60
  text "2.80mil" at 16814.48,12011.48 h60
  text "Bottom Solder" at 15014.97,11891.48 h60
  text "Solder Resist" at 15954.71,11891.48 h60
  text "0.40mil" at 16814.48,11891.48 h60
  text "3.5" at 17464.32,11891.48 h60
  text "Bottom Overlay" at 15014.97,11771.48 h60
  text ".Layer_Name" at 577,-858.49 h60
M13 Component Bodies Top:
  text ".Layer_Name" at 577,-858.49 h60
M14 Component Bodies Bottom:
  text ".Layer_Name" at 577,-858.49 h60
M15 Courtyards Top:
  text ".Layer_Name" at 577,-858.49 h60
M16 Courtyards Bottom:
  text ".Layer_Name" at 577,-858.49 h60
Drill Drawing:
  drawing of 184 lines, arcs and shapes, not listed
  text "Symbol" at 231.18,8615.01 h72
  text "Quantity" at 531.75,8615.01 h72
  text "Finished Hole Size" at 863.75,8615.01 h72
  text "Plated" at 1500.31,8615.01 h72
  text "Hole Type" at 1759.45,8615.01 h72
  text "Drill Layer Pair" at 2134.61,8615.01 h72
  text "Hole Tolerance" at 2858.94,8615.01 h72
  text "1" at 531.75,8490.69 h60
  text "118.11mil (3.000mm)" at 863.75,8490.69 h60
  text "NPTH" at 1500.31,8490.69 h60
  text "Round" at 1759.45,8490.69 h60
  text "Top Layer - Bottom Layer" at 2134.61,8490.69 h60
  text "22" at 531.75,8366.37 h60
  text "7.87mil (0.200mm)" at 863.75,8366.37 h60
  text "PTH" at 1500.31,8366.37 h60
  text "Round" at 1759.45,8366.37 h60
  text "Top Layer - Bottom Layer" at 2134.61,8366.37 h60
  text "6" at 531.75,8242.05 h60
  text "11.81mil (0.300mm)" at 863.75,8242.05 h60
  text "PTH" at 1500.31,8242.05 h60
  text "Round" at 1759.45,8242.05 h60
  text "Top Layer - Bottom Layer" at 2134.61,8242.05 h60
  text "174" at 531.75,8117.73 h60
  text "13.78mil (0.350mm)" at 863.75,8117.73 h60
  text "PTH" at 1500.31,8117.73 h60
  text "Round" at 1759.45,8117.73 h60
  text "Top Layer - Bottom Layer" at 2134.61,8117.73 h60
  text "114" at 531.75,7993.41 h60
  text "16.00mil (0.406mm)" at 863.75,7993.41 h60
  text "PTH" at 1500.31,7993.41 h60
  text "Round" at 1759.45,7993.41 h60
  text "Top Layer - Bottom Layer" at 2134.61,7993.41 h60
  text "20" at 531.75,7869.09 h60
  text "17.72mil (0.450mm)" at 863.75,7869.09 h60
  text "PTH" at 1500.31,7869.09 h60
  text "Round" at 1759.45,7869.09 h60
  text "Top Layer - Bottom Layer" at 2134.61,7869.09 h60
  text "20" at 531.75,7744.77 h60
  text "40.00mil (1.016mm)" at 863.75,7744.77 h60
  text "PTH" at 1500.31,7744.77 h60
  text "Round" at 1759.45,7744.77 h60
  text "Top Layer - Bottom Layer" at 2134.61,7744.77 h60
  text "40" at 531.75,7620.45 h60
  text "40.16mil (1.020mm)" at 863.75,7620.45 h60
  text "PTH" at 1500.31,7620.45 h60
  text "Round" at 1759.45,7620.45 h60
  text "Top Layer - Bottom Layer" at 2134.61,7620.45 h60
  text "28" at 531.75,7496.13 h60
  text "43.31mil (1.100mm)" at 863.75,7496.13 h60
  text "PTH" at 1500.31,7496.13 h60
  text "Round" at 1759.45,7496.13 h60
  text "Top Layer - Bottom Layer" at 2134.61,7496.13 h60
  text "+/-1.97mil" at 2858.94,7496.13 h60
  text "3" at 531.75,7371.81 h60
  text "45.28mil (1.150mm)" at 863.75,7371.81 h60
  text "PTH" at 1500.31,7371.81 h60
  text "Round" at 1759.45,7371.81 h60
  text "Top Layer - Bottom Layer" at 2134.61,7371.81 h60
  text "A" at 205.9,7361.82 h55.25
  text "10" at 531.75,7247.49 h60
  text "51.18mil (1.300mm)" at 863.75,7247.49 h60
  text "PTH" at 1500.31,7247.49 h60
  text "Round" at 1759.45,7247.49 h60
  text "Top Layer - Bottom Layer" at 2134.61,7247.49 h60
  text "6" at 531.75,7123.17 h60
  text "59.06mil (1.500mm)" at 863.75,7123.17 h60
  text "PTH" at 1500.31,7123.17 h60
  text "Round" at 1759.45,7123.17 h60
  text "Top Layer - Bottom Layer" at 2134.61,7123.17 h60
  text "4" at 531.75,6998.85 h60
  text "62.99mil (1.600mm)" at 863.75,6998.85 h60
  text "PTH" at 1500.31,6998.85 h60
  text "Round" at 1759.45,6998.85 h60
  text "Top Layer - Bottom Layer" at 2134.61,6998.85 h60
  text "25" at 531.75,6874.53 h60
  text "63.00mil (1.600mm)" at 863.75,6874.53 h60
  text "PTH" at 1500.31,6874.53 h60
  text "Round" at 1759.45,6874.53 h60
  text "Top Layer - Bottom Layer" at 2134.61,6874.53 h60
  text "8" at 531.75,6750.21 h60
  text "141.73mil (3.600mm)" at 863.75,6750.21 h60
  text "PTH" at 1500.31,6750.21 h60
  text "Round" at 1759.45,6750.21 h60
  text "Top Layer - Bottom Layer" at 2134.61,6750.21 h60
  text "2" at 531.75,6625.89 h60
  text "23.62mil (0.600mm)" at 863.75,6625.89 h60
  text "PTH" at 1500.31,6625.89 h60
  text "Slot" at 1759.45,6625.89 h60
  text "Top Layer - Bottom Layer" at 2134.61,6625.89 h60
  text "483 Total" at 531.75,6501.57 h60
  text "Slot definitions :" at 231.18,6414.54 h60
  text "Routed Path Length" at 681.9,6414.54 h60
  text "= Calculated from tool start centre position to tool end centre position." at 1221.64,6414.54 h60
  text "Hole Length" at 681.9,6364.82 h60
  text "= Routed Path Length + Tool Size = Slot length as defined in the PCB layout" at 1021.84,6364.82 h60
  text ".Layer_Name" at 577,-858.49 h60
M17 Embedded Cavity:
  text ".Layer_Name" at 577,-858.49 h60
M18 Embedded Assembly:
  text ".Layer_Name" at 577,-858.49 h60
M19 Embedded Keepout:
  text ".Layer_Name" at 567,-858.49 h60