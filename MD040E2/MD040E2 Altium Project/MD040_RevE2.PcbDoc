# Altium PCB MD040_RevE2.PcbDoc (part 4 of 5)
Units mm, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 127 x 127 mm, 4 copper layers (Top Layer, Signal Layer 1, Signal Layer 2, Bottom Layer), stack 1.554 mm thick; 336 components, 206 nets, 924 pads, 303 vias.
Unrouted connection lines stored in the file: 125.

## Via types
v1: diameter 0.5, hole 0.35, Top Layer to Bottom Layer, tented both sides, 210 vias
v2: diameter 0.5, hole 0.2, Top Layer to Bottom Layer, tented both sides, 65 vias
v3: diameter 0.5, hole 0.2, Top Layer to Bottom Layer, 22 vias
v4: diameter 3.6, hole 3.6, Top Layer to Bottom Layer, tented both sides, 5 vias
v5: diameter 0.5, hole 0.35, Top Layer to Bottom Layer, tented bottom, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
GND: C1.2 C2.2 C3.2 C4.2 C5.2 C6.2 C7.1 C8.1 C9.1 C10.1 C11.1 C12.2 C13.2 C14.2 C15.1 C16.2 C17.2 C18.2 C19.2 C20.2 C21.2 C22.2 C23.2 C24.2 C25.2 C26.1 C27.1 C28.2 C29.2 C30.2 C31.2 C32.2 C33.2 C34.2 C35.2 C36.2 C37.2 C38.2 C39.2 C40.2 C41.2 C42.2 C43.2 C44.2 C45.2 C46.2 C47.2 C48.2 C49.2 C52.1 C53.1 C54.2 C55.2 C56.2 C57.2 C58.2 C59.2 C61.1 C62.1 C63.1 C64.1 C66.1 C67.2 C68.2 C69.2 C70.2 C71.2 C72.2 C73.1 C74.2 D1.1 D2.1 D13.2 J1.4 J2.2 J3.9 J9.9 J10.13 J10.14 J12.1 J15.1 J21.1 J23.1 L2.2 R49.1 R60.1 R61.1 R77.1 R78.1 R84.1 R85.1 R86.1 R87.1 R93.1 R94.1 R95.1 R96.1 R104.1 R105.2 R106.2 R107.2 R108.2 R109.2 R110.1 R111.1 R113.1 R114.1 R115.1 R116.1 R117.1 R118.1 S1.3 S1.4 TP25.1 TP29.1 U1.10 U1.12 U1.15 U1.26 U1.29 U1.63 U1.76 U1.83 U1.90 U2.14 U2.16 U2.39 U2.49 U2.56 U2.65 U3.4 U3.9 U4.7 U4.18 U4.21 U4.25 U4.26 U5.2 U5.4 U5.5 U5.7 U5.11 U6.4 U7.3 U7.10 U7.13 U7.20 U7.22 U7.23 U7.45 Y1.2 Y2.3 | length 319.5
  Top Layer w0.152: v1@28.05,110.078 v1(28.15,110.078) ; C48.2@35.405,113.403 36.409,113.403 v1(36.422,113.39)
  Top Layer w0.254: R105.2@1.738,34.036 R106.2@1.738,35.632 1.738,38.278 R107.2@1.789,38.329 ; TP25.1@2.311,29.845 4.561,27.596 R113.1@8.888,27.596 8.905,27.578 R115.1@12.083,27.578 12.197,27.693 R111.1@15.269,27.693 18.312,27.693 R116.1@18.318,27.686 21.647,27.686 R117.1@21.663,27.702 ; C7.1@2.794,44.167 v1@3.654,44.167 ; D2.1@11.608,111.038 11.608,112.523 12.008,112.923 12.008,113.864 12.347,114.202 C23.2@12.903,114.202 ; C16.2@13.046,38.379 13.046,38.799 15.871,41.625 U1.26@17.572,41.625 17.572,42.591 17.856,42.875 18.78,42.875 19.072,42.583 U1.29@19.072,41.625 19.072,40.607 16.896,38.43 C13.2@16.043,38.43 ; C15.1@13.64,49.208 14.202,49.208 14.844,49.85 U1.12@15.847,49.85 17.109,49.85 17.17,49.911 ; D1.1@14.011,110.734 14.097,110.819 v1(14.097,113.005) ; C29.2@14.45,106.078 v1(14.45,106.778) ; U1.15@15.847,48.35 16.798,48.35 17.17,48.722 17.17,49.911 ; U1.10@15.847,50.85 16.869,50.85 17.17,50.548 17.17,49.911 ; v1(16.45,108.478) 16.45,107.428 C31.2@16.4,107.378 17.448,107.378 18.098,108.028 C33.2@18.355,108.028 C32.2@19.39,108.028 C25.2@20.45,108.028 ; C8.1@16.51,61.587 v1@16.51,62.747 ; C9.1@17.78,61.535 v1@17.78,62.76 ; C10.1@19.05,61.755 19.093,61.799 19.093,62.781 C11.1@20.31,62.781 ; C18.2@22.031,60.096 22.031,59.576 22.083,59.576 22.572,59.087 U1.90@22.572,57.075 ; U2.39@25.947,97.969 27.355,96.561 27.355,96.292 v1(27.8,95.847) 27.111,95.159 27.111,94.63 C34.2@27.455,94.286 ; U1.83@26.072,57.075 26.072,57.952 26.566,58.445 v1(28.083,58.445) 28.133,58.395 29.159,58.395 29.572,57.982 U1.76@29.572,57.075 ; v1(26.153,103.997) 26.654,104.498 U2.56@26.654,104.545 ; v1(27.35,110.778) v1@28.05,110.078 ; v1@27.61,3.009 J2.2@29.64,3.009 ; v1@28.649,61.204 R109.2@29.388,61.204 ; U2.49@29.129,102.065 30.22,102.065 v1(30.542,101.744) ; C28.2@29.757,107.592 29.757,107.641 v1(30.777,108.661) ; C30.2@30.557,106.792 31.543,107.778 v1(31.75,107.778) ; U1.63@31.297,49.35 35.257,49.35 36.21,48.397 C17.2@37.165,48.397 37.989,48.397 ; C20.2@31.346,106.006 31.346,106.274 v1(32.25,107.178) ; C38.2@31.39,112.453 C40.2@30.216,112.453 30.216,112.583 29.422,113.377 29.422,114.883 31.433,114.883 C35.2@31.462,114.853 C36.2@32.54,114.853 ; R108.2@31.66,61.205 v1@32.638,61.205 ; C36.2@32.54,114.853 C37.2@33.659,114.853 ; R77.1@33.606,103.013 33.686,103.013 v1(34.15,103.478) ; v1(33.891,64.569) 34.048,64.726 C74.2@36.304,64.726 ; C26.1@33.993,90.475 v1(33.993,91.44) ; C21.2@35.255,98.019 35.484,98.019 v1(36.398,97.104) 38.669,99.375 C45.2@39.7,99.375 39.722,99.353 U5.4@42.597,99.353 U5.11@44.297,99.353 ; v1(37.801,119.646) 38.009,119.438 U6.4@38.009,118.933 ; 37.951,48.397 38.498,47.85 39.662,47.85 C14.2@39.713,47.798 v1@41.153,47.798 ; C27.1@37.954,83.972 38.146,84.164 43.143,84.164 44.171,85.192 C12.2@44.171,86.19 ; 39.237,110.134 39.237,110.865 v1(39.35,110.978) ; L2.2@39.604,116.744 40.66,116.744 v1(40.97,116.434) ; U5.5@42.597,98.853 43.797,98.853 U5.11@44.297,99.353 ; U5.2@42.597,100.353 44.297,100.353 U5.11@44.797,99.853 U5.11@44.297,99.353 ; S1.3@43.151,57.872 47.6,57.872 ; C47.2@45.964,121.235 R78.1@45.964,122.834 45.964,123.693 v1(45.999,123.728) ; U4.7@46.468,112.06 v1@48.229,112.06 ; U5.7@46.997,99.353 47.805,99.353 48.145,99.013 48.145,97.915 48.552,97.509 C46.2@49.568,97.509 ; v1(47.6,55.804) 47.6,57.872 ; v1(49.606,96.037) 49.606,97.47 C46.2@49.568,97.509 ; R49.1@51.421,68.093 51.421,66.456 C19.2@51.621,66.256 v1@51.621,65.21 ; S1.4@52.251,57.872 47.6,57.872 ; C44.2@52.391,99.335 50.564,97.509 C46.2@49.568,97.509 ; U4.18@53.368,109.46 54.951,109.46 55.364,109.872 C41.2@55.88,109.872 55.88,110.709 55.179,111.41 U4.21@53.368,111.41 ; U4.26@53.368,114.66 U4.25@53.368,114.01 v1@55.601,114.01 ; v1@66.909,118.813 D13.2@67.913,118.813 67.913,116.673 R118.1@68.035,116.551 ; C1.2@67.156,7.249 67.233,7.325 C2.2@69.367,7.325 71.044,7.325 J1.4@72.82,5.549 72.823,5.549 74.155,4.216 78.715,4.216 81.41,6.912 94.821,6.912 94.856,6.947 C71.2@107.824,6.947 108.703,6.947 108.929,6.721 R104.1@109.861,6.721 ; v1@67.726,19.289 C4.2@68.694,19.289 ; v1(67.729,22.289) C5.2@68.694,22.289 ; v1@67.767,16.231 67.77,16.231 67.774,16.227 C3.2@68.694,16.227 ; v1@67.783,25.289 C6.2@68.694,25.289 ; v1@72.669,65.075 72.694,65.05 C62.1@72.694,64.033 ; v1@74.93,86.131 R84.1@75.725,86.131 ; v1@75.08,66.573 75.08,66.474 75.87,65.684 R85.1@76.265,65.684 ; v1@75.347,76.286 76.513,76.286 76.487,76.261 R86.1@76.487,75.082 ; v1@88.896,75.986 C63.1@89.811,75.071 ; C49.2@91.973,75.451 93.605,75.451 94.689,74.367 U7.23@94.689,72.026 ; U7.45@97.889,58.493 97.889,55.577 99.898,53.569 C56.2@103.698,53.569 ; v2(98.136,65.363) 99.092,64.406 106.418,64.406 107.371,65.359 C57.2@107.371,65.405 ; U7.45@98.439,65.363 U7.45@98.439,69.026 ; U7.45@99.122,65.477 99.863,66.218 U7.45@100.399,66.218 ; U7.45@100.272,70.859 U7.45@98.439,69.026 ; U7.45@100.492,66.311 106.511,66.311 107.371,65.451 C57.2@107.371,65.405 ; U7.45@100.639,70.859 100.742,70.756 U7.20@102.189,70.756 ; U7.3@102.189,59.961 103.371,59.961 104.541,58.791 C58.2@105.588,58.791 ; C59.2@105.288,73.766 103.103,73.766 102.189,72.852 102.189,72.026 100.707,72.026 98.439,69.759 U7.45@98.439,69.026 ; v1(115.186,93.475) C64.1@116.035,92.626 ; C61.1@117.383,65.407 117.381,65.405 C57.2@107.371,65.405 ; C61.1@117.5,65.395 117.516,65.411 C66.1@117.516,68.325 ; C69.2@120.139,21.978 120.876,21.978 121.26,21.595 122.303,21.595 R95.1@122.389,21.682 v1@122.389,21.019 ; C67.2@120.218,36.872 120.738,36.872 120.914,36.697 R93.1@122.002,36.697 ; C68.2@120.309,29.202 120.922,28.589 122.11,28.589 R94.1@122.152,28.632 v1@122.152,27.842 ; C70.2@120.367,14.473 121.077,14.473 121.077,14.412 121.533,13.956 R96.1@122.377,13.956 v1@122.377,12.967 ; v1@122.301,35.763 R93.1@122.301,36.663
  other v1: 27.549,3.023 106.705,6.985 122.387,12.929 67.783,16.231 67.732,19.304 122.403,20.98 67.783,25.298 13.792,27.635 122.199,27.838 122.311,35.703 1.743,37.033 16.449,41.629 3.749,44.171 41.189,47.803 95.813,56.261 99.275,56.261 97.028,56.286 98.13,56.286 100.392,56.286 95.794,57.311 97.004,57.342 98.149,57.342 99.257,57.379 100.355,57.379 22.447,58.791 32.655,61.2 28.512,61.227 16.51,62.738 17.78,62.765 19.101,62.794 72.669,65.126 51.664,65.176 75.057,66.599 117.5,66.878 46.528,68.303 95.914,73.381 99.377,73.381 97.13,73.406 98.232,73.406 100.494,73.406 95.896,74.43 97.106,74.462 98.25,74.462 99.358,74.498 88.875,76.042 75.352,76.302 43.18,84.252 74.946,86.157 102.906,98.545 15.45,108.478 17.35,108.478 17.25,111.278 48.311,112.116 17.25,112.277 40.333,112.62 55.651,114.046 17.35,114.578 29.439,114.884 17.35,115.678 2.25,118.5 66.873,118.823
  other v2: 95.936,58.763 97.036,58.763 98.136,58.763 99.236,58.763 100.336,58.763 95.936,59.863 97.036,59.863 98.136,59.863 99.236,59.863 100.336,59.863 95.936,60.963 97.036,60.963 98.136,60.963 99.236,60.963 100.336,60.963 95.936,62.063 97.036,62.063 98.136,62.063 99.236,62.063 100.336,62.063 95.936,63.163 97.036,63.163 98.136,63.163 99.236,63.163 100.336,63.163 95.936,64.263 97.036,64.263 98.136,64.263 99.236,64.263 100.336,64.263 95.936,65.363 97.036,65.363 99.236,65.363 100.336,65.363 95.936,66.463 97.036,66.463 98.136,66.463 99.236,66.463 100.336,66.463 95.936,67.563 97.036,67.563 98.136,67.563 99.236,67.563 100.336,67.563 95.936,68.663 97.036,68.663 98.136,68.663 99.236,68.663 100.336,68.663 95.936,69.763 97.036,69.763 98.136,69.763 99.236,69.763 100.336,69.763 95.936,70.863 97.036,70.863 98.136,70.863 99.236,70.863 100.336,70.863 95.936,71.963 97.036,71.963 98.136,71.963 99.236,71.963 100.336,71.963
  other v3: 44.147,98.553 45.447,98.553 22.532,99.788 24.2,99.788 44.147,99.853 45.447,99.853 23.366,100.623 21.549,100.771 25.183,100.771 44.147,101.153 45.447,101.153 22.383,101.605 24.349,101.605 21.549,102.44 25.183,102.44 23.366,102.588 22.532,103.423 24.2,103.423 35.07,109.73 34.445,110.23 35.695,110.23 35.07,110.73
GUI_STATUS: D8.2 U1.35 | length 19.3
  Top Layer w0.254: D8.2@8.888,32.508 8.888,34.729 9.846,35.687 17.825,35.687 22.049,39.911 22.049,41.625 U1.35@22.072,41.625
ID1: R99.2 R105.1 U1.33 | length 23.4
  Top Layer w0.254: R105.1@3.138,34.036 3.215,34.112 R99.2@4.659,34.112 5.332,34.112 5.332,33.552 5.524,33.36 6.595,33.36 6.786,33.552 6.786,34.501 8.881,36.595 17.449,36.595 21.049,40.195 21.049,41.625 U1.33@21.072,41.625
ID2: R100.2 R106.1 U1.32 | length 21.3
  Top Layer w0.254: R106.1@3.138,35.632 3.168,35.662 R100.2@4.659,35.662 4.659,36.779 4.929,37.049 17.261,37.049 20.572,40.36 U1.32@20.572,41.625
ID3: R101.2 R107.1 U1.31 | length 20
  Top Layer w0.254: R107.1@3.189,38.329 3.24,38.379 R101.2@4.685,38.379 4.685,37.632 4.813,37.503 16.954,37.503 20.072,40.621 U1.31@20.072,41.625
ID4: R102.2 R108.1 U1.84 | length 11.5
  Top Layer w0.254: U1.84@25.572,57.075 25.572,58.287 27.115,59.83 29.959,59.83 30.531,60.401 30.531,62.066 31.07,62.605 R108.1@31.66,62.605 R102.2@31.66,64.085
ID5: R103.2 R109.1 U1.85 | length 10
  Top Layer w0.254: 25.095,57.847 25.095,57.098 U1.85@25.072,57.075 25.072,58.88 28.457,62.265 28.731,62.538 28.731,62.604 R109.1@29.388,62.604 R103.2@29.388,64.084
"INDEXER HOME": D11.2 U1.39 | length 11.5
  Top Layer w0.254: D11.2@18.301,32.537 18.301,34.236 24.049,39.985 24.049,41.602 U1.39@24.072,41.625
M0/nSCS/VREF1/EN4_2: J4.16 J26.2 | length 11.6
  Top Layer w0.254: J4.16@66.464,73.583 69.689,73.583 ; J26.2@69.444,67.361 70.632,67.361 71.28,68.009 71.28,71.993 69.689,73.584
MANUAL_VREF: C19.1 J7.2 R44.1 R49.2 | length 6.8
  Top Layer w0.254: C19.1@52.821,66.256 55.791,66.256 J7.2@55.905,66.371 ; C19.1@53.021,66.456 R49.2@53.021,68.093 R44.1@53.021,70.104
MCU_3V3: C12.1 C14.1 C16.1 C17.1 C18.1 C63.2 D5.2 D7.2 J10.10 R1.1 R4.1 R20.2 R22.2 R29.1 R35.1 R44.2 R83.2 R88.2 R99.1 R100.1 R101.1 R102.1 R103.1 TP27.1 U1.25 U1.64 U1.87 U1.89 U7.25 | length 327.2
  Top Layer w0.254: R4.1@3.688,47.155 R35.1@5.406,47.155 ; R99.1@6.059,34.112 R100.1@6.059,35.662 ; R101.1@6.085,38.379 C16.1@11.846,38.379 15.847,42.381 U1.25@15.847,43.35 17.01,43.35 v1@17.678,44.018 ; J10.10@22.149,84.709 22.149,83.363 23.308,82.204 23.308,76.263 23.983,75.588 27.477,75.588 28.388,76.499 28.388,77.217 29.063,77.892 30.017,77.892 30.692,77.217 30.692,74.104 v1(30.984,73.812) ; U1.87@24.072,57.075 24.072,55.873 23.825,55.626 23.546,55.626 ; R22.2@30.32,73.711 30.882,73.711 v1(30.984,73.812) ; v5(30.984,68.547) 31.317,68.88 46.824,68.88 48.048,70.104 R44.2@51.421,70.104 ; R20.2@31.631,73.762 31.58,73.812 v1(30.984,73.812) ; R102.1@31.66,65.485 29.389,65.485 R103.1@29.388,65.484 24.158,65.484 23.231,64.557 C18.1@23.231,60.096 23.072,59.937 U1.89@23.072,57.075 23.072,55.795 23.241,55.626 23.546,55.626 ; 37.748,49.597 38.55,50.398 C14.1@39.713,50.398 ; 37.786,49.597 C17.1@37.165,49.597 36.912,49.85 U1.64@31.297,49.85 29.932,49.85 29.134,50.648 26.67,50.648 25.679,49.657 24.196,49.657 23.546,50.307 23.546,55.626 ; C12.1@44.171,87.19 44.171,88.232 43.477,88.925 42.278,88.925 D5.2@42.088,89.116 42.088,93.345 TP27.1@42.062,93.37 76.83,93.37 D7.2@79.345,90.856 ; R1.1@79.14,2.939 79.158,2.921 v1(80.366,2.921) ; D7.2@79.451,90.83 82.169,88.113 82.169,83.702 87.694,78.177 87.694,74.924 88.947,73.671 C63.2@89.811,73.671 89.965,73.671 90.907,72.73 R83.2@90.907,71.668 91.926,71.668 92.837,70.756 U7.25@94.689,70.756 ; v1@88.443,72.568 88.875,72.136 R88.2@88.875,71.648 R88.2@88.829,71.648
  Bottom Layer w0.254: v1(4.293,47.193) 7.976,47.193 11.065,44.104 12.852,44.104 ; v1(6.055,34.925) 12.852,41.723 12.852,44.104 ; J10.10@22.149,84.709 22.149,85.005 23.301,86.157 23.301,88.176 24.215,89.09 37.655,89.09 41.935,93.37 TP27.1@42.062,93.37 ; v1(23.545,51.008) 17.671,45.134 v1(17.671,44.104) 12.852,44.104 ; v1(30.546,65.47) 30.546,65.618 30.984,66.055 v1(30.984,73.812) ; v1@80.416,2.997 80.848,2.997 81.636,3.785 81.636,64.675 88.287,71.326 88.287,72.455 v1(88.468,72.636) 88.59,72.757 v1(90.873,72.757)
MCU_UARTRXD: J10.8 U1.61 | length 49.9
  Top Layer w0.254: v1@27.178,49.985 v1@27.243,49.985 ; v1(27.243,50.038) 28.499,50.038 30.187,48.35 U1.61@31.297,48.35
  Bottom Layer w0.254: J10.8@24.689,84.709 27.313,82.086 32.859,82.086 34.493,80.452 34.493,60.931 27.178,53.616 v1@27.178,49.985
MCU_UARTTXD: J10.6 U1.60 | length 48.6
  Top Layer w0.254: v1(28.067,48.539) 28.757,47.85 U1.60@31.297,47.85
  Bottom Layer w0.254: J10.6@27.229,84.709 29.104,82.834 33.066,82.834 35.585,80.315 35.585,61.214 28.068,53.697 v1@28.068,48.565
MODE2/IPROPI4: J4.8 J16.2 R14.1 R79.2 U7.29 | length 110.4
  Top Layer w0.254: R14.1@65.09,23.439 65.09,29.495 76.637,41.042 v1(76.637,41.119) ; J4.8@66.464,83.743 66.515,83.795 70.485,83.795 72.466,81.813 77.735,81.813 J16.2@79.197,83.276 ; R79.2@79.113,86.233 79.197,86.149 J16.2@79.197,83.276 ; U7.29@94.689,68.216 88.595,68.216 85.722,71.089 85.722,76.631 79.197,83.156 J16.2@79.197,83.276
  Bottom Layer w0.254: v1(76.637,41.119) 76.637,61.747 76.683,61.747 82.22,67.285 82.22,80.188 81.458,80.95 81.458,81.015 J16.2@79.197,83.276
MODE/MODE1: J4.6 R11.1 U7.28 | length 126.9
  Top Layer w0.254: R11.1@36.84,18.249 41.109,18.249 62.459,39.599 v1(62.459,40.97) ; J4.6@66.464,86.283 69.748,86.283 v1(70.663,87.198) 79.502,87.198 80.721,85.979 80.721,82.753 86.233,77.241 86.233,71.493 88.875,68.851 U7.28@94.689,68.851
  Bottom Layer w0.254: v1(62.459,40.97) 67.72,46.231 67.72,63.89 68.238,64.408 68.238,84.773 v1(70.663,87.198)
MSP_DECAY0/SDI/DECAY/EN1: J8.5 U1.65 | length 33
  Top Layer w0.254: U1.65@31.297,50.35 36.659,50.35 38.537,52.228 52.712,52.228 57.507,57.023 J8.5@61.523,57.023
MSP_DECAY1/SDO/RSVD/EN2: J8.3 U1.66 | length 33.8
  Top Layer w0.254: U1.66@31.297,50.85 36.346,50.85 38.846,53.35 50.834,53.35 57.047,59.563 J8.3@61.523,59.563
MSP_DIR/IN2/PH2: J8.11 U1.52 | length 32.5
  Top Layer w0.254: U1.52@31.297,43.85 39.724,43.85 41.105,45.231 49.263,45.231 51.349,47.317 55.091,47.317 57.19,49.416 58.834,49.416 58.847,49.403 J8.11@61.523,49.403
MSP_ENABLE/IN1/PH1: J8.13 U1.51 | length 31.7
  Top Layer w0.254: U1.51@31.297,43.35 39.866,43.35 41.293,44.777 49.451,44.777 51.537,46.863 J8.13@61.523,46.863
MSP_IPROPI1/IPROPI2: C10.2 R41.1 U1.98 | length 52.9
  Top Layer w0.254: U1.98@18.572,57.075 18.572,60.278 C10.2@19.05,60.755 19.038,60.755 18.39,61.403 18.39,65.946 23.415,70.971 44.098,70.971 51.791,78.664 R41.1@56.648,78.664
MSP_IPROPI2/IPROPI3: C9.2 R40.1 U1.99 | length 54.7
  Top Layer w0.254: C9.2@17.78,60.535 17.768,60.535 17.203,61.099 17.203,65.585 23.195,71.577 42.647,71.577 52.273,81.203 R40.1@56.608,81.203 ; C9.2@17.822,60.535 17.822,59.205 18.072,58.955 U1.99@18.072,57.075
MSP_M0/nSCS/VREF1/EN4: J4.15 R54.2 TP15.1 U1.3 | length 86.1
  Top Layer w0.254: U1.3@15.847,54.35 15.824,54.373 14.273,54.373 13.31,55.336 13.31,65.033 TP15.1@9.093,69.25 9.093,70.834 9.761,71.501 R54.2@16.662,71.501 ; v1@23.444,68.072 25.16,69.788 46.448,69.788 50.236,73.576 55.093,73.576 55.1,73.583 56.296,73.583 J4.15@61.514,73.583
  Signal Layer 2 w0.254: TP15.1@9.093,69.25 13.786,64.557 17.516,64.557 21.031,68.072 v1@23.444,68.072
  other v1: 23.419,68.072
MSP_M1/SCLK/IN4/PH4: J8.7 R3.1 U1.54 U1.62 | length 50.2
  Top Layer w0.254: U1.62@31.297,48.85 32.151,48.85 32.918,48.082 35.687,48.082 36.708,47.061 ; R3.1@34.17,38.3 34.17,38.857 29.972,43.055 29.972,44.491 30.307,44.827 31.274,44.827 U1.54@31.297,44.85 31.32,44.873 31.32,44.856 34.53,44.856 34.941,45.267 34.941,45.295 36.708,47.061 ; J8.7@61.523,54.483 61.472,54.432 56.47,54.432 52.697,50.659 45.584,50.659 41.458,46.533 37.236,46.533 36.708,47.061
MSP_M1_PD: R3.2 U1.50 | length 5
  Top Layer w0.254: U1.50@29.572,41.625 29.572,40.887 32.16,38.3 R3.2@32.77,38.3
MSP_MODE2/IPROPI4: C8.2 R39.1 U1.100 | length 57.1
  Top Layer w0.254: C8.2@16.51,60.587 16.498,60.587 15.933,61.152 15.933,65.027 23.144,72.238 41.148,72.238 52.705,83.795 R39.1@56.65,83.795 ; C8.2@16.541,60.587 16.541,59.379 17.572,58.348 U1.100@17.572,57.075
MSP_MODE/MODE1: J4.5 U1.67 | length 55.4
  Top Layer w0.254: v1(29.743,51.384) 30.513,51.384 30.525,51.373 31.274,51.373 U1.67@31.297,51.35 ; v1@38.938,73.457 51.714,86.233 57.531,86.233 57.581,86.283 J4.5@61.514,86.283
  Bottom Layer w0.254: v1(29.743,51.384) 29.743,53.442 34.012,57.711 34.012,57.79 37.054,60.832 37.054,71.547 v1(38.989,73.482)
MSP_nFAULT: J4.1 U1.24 | length 110.9
  Top Layer w0.254: U1.24@15.847,43.85 15.824,43.827 14.857,43.827 14.63,43.6 14.63,42.373 12.14,39.883 5.516,39.883 1.346,44.053 1.346,65.507 8.738,72.898 35.331,72.898 53.721,91.288 57.511,91.288 57.586,91.363 J4.1@61.514,91.363
MSP_nHOME/OCPM: J4.3 U1.38 | length 68.2
  Top Layer w0.254: U1.38@23.572,41.625 23.572,43.129 26.925,46.482 v1@27,46.482 ; v1@37.871,73.521 53.199,88.849 57.463,88.849 57.488,88.823 J4.3@61.514,88.823
  Bottom Layer w0.254: v1@27,46.482 27.498,46.482 28.913,47.897 28.913,53.696 36.424,61.206 36.424,72.085 v1(37.871,73.533)
  other v1: 26.924,46.457
MSP_nSCS: R54.1 U1.59 | length 35.1
  Top Layer w0.254: R54.1@17.75,71.501 17.75,67.816 15.392,65.458 15.392,57.582 18.13,54.844 18.13,54.822 25.602,47.35 U1.59@31.297,47.35
MSP_nSLEEP: J8.15 U1.41 | length 43.7
  Top Layer w0.254: U1.41@25.072,41.625 25.095,41.648 25.095,38.763 27.573,36.285 33.444,36.285 41.481,44.323 J8.15@61.523,44.323
MSP_RSVD/IPROPI1: C11.2 R42.1 U1.97 | length 50.7
  Top Layer w0.254: U1.97@19.072,57.075 19.072,59.116 20.31,60.354 C11.2@20.31,61.781 20.607,61.781 21.188,62.362 21.188,67.792 23.83,70.434 45.415,70.434 51.079,76.098 R42.1@56.633,76.098
MSP_STEP/IN3/PH3: J8.9 U1.53 | length 33.4
  Top Layer w0.254: U1.53@31.297,44.35 39.582,44.35 40.917,45.685 49.074,45.685 51.16,47.771 54.287,47.771 58.459,51.943 J8.9@61.523,51.943
MSP_TOFF/RSVD/EN3: J8.1 R2.1 U1.22 | length 56.3
  Top Layer w0.254: R2.1@13.047,43.622 14.275,44.85 U1.22@15.847,44.85 19.294,44.85 22.327,47.882 v1@22.327,47.879 ; v1@24.454,50.235 33.909,59.69 53.823,59.69 56.236,62.103 57.772,62.103 J8.1@61.523,62.103
  Bottom Layer w0.254: v1(22.301,47.904) 24.511,50.114 v1(24.511,50.267)
MSP_TOFF_PD: R2.2 U1.23 | length 4
  Top Layer w0.254: R2.2@13.047,42.222 14.097,43.272 14.097,43.774 14.672,44.35 U1.23@15.847,44.35
MSP_VREF/VREF2: J6.2 TP17.1 U1.4 | length 68
  Top Layer w0.254: TP17.1@10.316,65.484 10.58,65.748 11.953,65.748 12.856,64.845 12.856,55.148 14.131,53.873 15.824,53.873 U1.4@15.847,53.85 ; v1(23.444,67.234) 25.544,69.334 46.636,69.334 50.424,73.122 53.611,73.122 55.905,70.828 J6.2@55.905,69.926
  Signal Layer 2 w0.254: TP17.1@10.316,65.484 12.217,65.484 13.598,64.103 17.704,64.103 20.835,67.234 v1(23.444,67.234)
NetC1_1: C1.1 J1.10 TP40.1 | length 20.9
  Top Layer w0.254: C1.1@67.156,8.449 67.156,10.744 67.197,10.744 69.621,13.169 J1.10@72.82,13.169 74.13,14.478 83.902,14.478 TP40.1@84.106,14.275
NetC2_1: C2.1 J1.8 TP39.1 | length 24.1
  Top Layer w0.254: C2.1@69.367,8.525 69.34,8.552 69.34,10.689 72.76,10.689 J1.8@72.82,10.629 73.975,9.474 78.054,9.474 78.956,10.376 80.734,10.376 82.436,12.078 86.174,12.078 87.342,13.246 TP39.1@89.165,13.246
NetC7_2: C7.2 R4.2 U1.9 | length 17.4
  Top Layer w0.254: C7.2@2.794,45.167 2.794,47.148 R4.2@2.788,47.155 2.788,48.127 3.632,48.971 6.248,48.971 7.431,50.153 12.573,50.153 13.769,51.35 U1.9@15.847,51.35
NetC13_1: C13.1 U1.27 | length 5.5
  Top Layer w0.254: C13.1@14.843,38.43 14.843,38.916 15.577,39.649 17.228,39.649 18.072,40.493 U1.27@18.072,41.625
NetC15_2: C15.2 R35.2 U1.11 | length 10.9
  Top Layer w0.254: R35.2@6.306,47.155 8.707,49.555 12.742,49.555 13.394,50.208 C15.2@13.64,50.208 13.782,50.35 U1.11@15.847,50.35
NetC26_2: C26.2 J10.1 R64.2 | length 6.5
  Top Layer w0.254: R64.2@29.958,90.688 31.054,90.688 31.267,90.475 C26.2@32.793,90.475 ; J10.1@32.309,87.249 32.877,87.818 32.877,90.531 C26.2@32.877,90.62
NetC27_2: C27.2 J10.3 R65.2 | length 13
  Top Layer w0.254: R65.2@27.434,90.688 29.769,88.353 J10.3@29.769,87.249 ; v1(35.56,83.896) 35.636,83.972 C27.2@36.754,83.972
  Bottom Layer w0.254: J10.3@29.769,87.249 31.115,85.903 33.891,85.903 35.56,84.234 v1(35.56,83.896)
NetC38_1: C38.1 C40.1 R68.1 U3.1 | length 14.3
  Top Layer w0.254: C40.1@30.216,111.253 C38.1@31.39,111.253 31.39,111.018 v1(32.019,110.388) 32.338,110.388 33.896,108.83 U3.1@34.095,108.83 ; v1(37.644,104.735) 37.644,103.662 R68.1@37.655,103.65
  Bottom Layer w0.254: v1(32.019,110.388) 33.768,108.64 34.19,108.64 35.893,106.936 35.893,106.485 v1(37.644,104.735)
NetC39_1: C39.1 U3.3 | length 3.5
  Top Layer w0.254: C39.1@33.505,106.483 33.505,107.362 34.346,108.203 35.006,108.203 35.395,108.592 U3.3@35.395,108.83
NetC45_1: C45.1 R74.1 U5.1 | length 5.4
  Top Layer w0.254: R74.1@37.636,101.469 38.321,101.469 39.214,100.575 C45.1@39.7,100.575 40.958,100.575 41.237,100.853 U5.1@42.597,100.853
NetC46_1: C46.1 U5.8 | length 2.7
  Top Layer w0.254: U5.8@46.997,99.853 48.114,99.853 48.427,99.541 C46.1@49.568,99.541
NetC50_1: C50.1 U7.44 | length 2.7
  Top Layer w0.254: C50.1@92.146,57.554 92.239,57.554 93.38,58.695 U7.44@94.386,58.695
NetC50_2: C50.2 U7.43 | length 2.4
  Top Layer w0.254: C50.2@92.146,58.909 92.381,58.909 92.837,59.365 94.351,59.365 U7.43@94.386,59.33
NetC51_2: C51.2 U7.1
NetC62_2: C62.2 J5.2 R19.2 | length 43.4
  Top Layer w0.254: v1(67.843,30.963) 67.962,30.844 R19.2@67.962,27.991 ; v1(70.714,64.078) 70.758,64.033 C62.2@71.694,64.033 71.694,66.087 J5.2@73,67.393
  Bottom Layer w0.254: v1(67.843,30.963) 67.843,40.996 72.085,45.237 72.085,62.76 72.032,62.76 v1(70.714,64.078)
NetC72_1: C72.1 U1.13 Y2.1 | length 10.4
  Top Layer w0.152: v1(11.718,48.95) 11.741,48.973 12.934,48.973 13.275,48.632 14.234,48.632 14.952,49.35 U1.13@15.847,49.35
  Top Layer w0.254: Y2.1@8.499,51.072 9.567,51.072 ; v1(9.542,51.528) 9.542,51.097 9.567,51.072 ; C72.1@10.313,50.974 10.216,51.072 9.567,51.072
  Bottom Layer w0.254: v1(9.542,51.528) 9.542,51.126 v1(11.718,48.95)
NetC73_2: C73.2 U1.14 Y2.2 | length 12.1
  Top Layer w0.152: v1(12.629,48.447) 12.796,48.279 14.38,48.279 14.877,48.776 15.773,48.776 U1.14@15.847,48.85
  Top Layer w0.254: Y2.2@8.499,51.972 9.078,51.972 9.303,52.197 10.296,52.197 10.262,52.232 v1(10.262,53.192)
  Bottom Layer w0.254: v1(10.262,53.192) 12.629,50.825 v1(12.629,48.447)
NetD1_2: D1.2 R58.1 | length 3.5
  Top Layer w0.254: R58.1@12.928,105.934 12.928,108.051 D1.2@13.911,109.034
NetD2_2: D2.2 R59.1 | length 3.3
  Top Layer w0.254: D2.2@11.539,109.051 D2.2@11.539,109.221 ; R59.1@11.608,105.979 11.608,109.026 D2.2@11.633,109.051
NetD3_2: D3.2 L1.2 | length 3.2
  Top Layer w0.254: L1.2@31.905,118.156 32.357,117.704 D3.2@33.653,117.704 34.336,117.021 v1(34.336,116.685)
NetD4_1: D4.1 Q1.3 | length 2.5
  Top Layer w0.254: Q1.3@74.763,117.538 75.401,116.901 D4.1@76.963,116.901
NetD5_1: D5.1 R110.2 | length 2
  Top Layer w0.254: R110.2@42.06,85.564 42.088,85.593 D5.1@42.088,87.516
NetD6_1: D6.1 R114.2 | length 2
  Top Layer w0.254: R114.2@5.831,28.945 5.844,28.958 D6.1@5.844,30.907
NetD7_1: D7.1 R112.2 | length 1.8
  Top Layer w0.254: R112.2@75.96,90.856 D7.1@77.745,90.856
NetD8_1: D8.1 R113.2 | length 1.9
  Top Layer w0.254: R113.2@8.888,28.996 D8.1@8.888,30.908
NetD9_1: D9.1 R115.2 | length 1.9
  Top Layer w0.254: R115.2@12.008,29.002 12.08,29.074 D9.1@12.08,30.918
NetD10_1: D10.1 R111.2 | length 1.8
  Top Layer w0.152: R111.2@15.269,29.093 D10.1@15.269,30.934
NetD11_1: D11.1 R116.2 | length 1.9
  Top Layer w0.254: D11.1@18.301,30.937 18.301,29.104 R116.2@18.318,29.086
NetD12_1: D12.1 R117.2 | length 1.9
  Top Layer w0.254: R117.2@21.663,29.102 21.715,29.153 D12.1@21.715,30.937
NetD13_1: D13.1 Q1.1 R97.1 | length 7.2
  Top Layer w0.254: D13.1@70.113,118.813 71.121,118.813 71.446,118.488 Q1.1@72.763,118.488 72.866,118.591 R97.1@77.163,118.591
NetF1_2: F1.2 J12.2 | length 21.4
  Top Layer w2.54: J12.2@98.984,120.39 J12.2@98.984,110.23 105.148,104.065 F1.2@107.645,104.065
NetJ1_6: J1.6 TP38.1 | length 13.1
  Top Layer w0.254: J1.6@72.82,8.089 73.975,6.934 77.292,6.934 79.934,9.576 81.983,9.576 82.009,9.601 TP38.1@84.346,9.601
NetJ2_4: J2.4 TP46.1 | length 12.1
  Top Layer w0.254: TP46.1@17.501,5.537 17.512,5.549 J2.4@29.64,5.549
NetJ3_2: J3.2 R20.1 | length 3.1
  Top Layer w0.254: J3.2@32.122,76.683 32.122,75.124 32.617,74.63 32.617,73.776 R20.1@32.631,73.762
NetJ3_4: J3.4 R22.1 | length 3.1
  Top Layer w0.254: R22.1@29.32,73.711 29.32,74.608 29.582,74.87 J3.4@29.582,76.683
NetJ4_7: J4.7 R39.2 | length 3.9
  Top Layer w0.254: R39.2@57.65,83.795 57.701,83.743 J4.7@61.514,83.743
NetJ4_9: J4.9 R40.2 | length 3.9
  Top Layer w0.254: R40.2@57.608,81.203 J4.9@61.514,81.203
NetJ4_11: J4.11 R41.2 | length 3.9
  Top Layer w0.254: R41.2@57.648,78.664 J4.11@61.514,78.663
NetJ4_13: J4.13 R42.2 | length 3.9
  Top Layer w0.254: R42.2@57.633,76.098 57.658,76.123 J4.13@61.514,76.123
NetJ9_2: J9.2 R63.2 | length 4.6
  Top Layer w0.254: R63.2@28.45,116.778 28.45,117.478 29.126,118.154 29.126,121.085 J9.2@29.119,121.092
NetJ9_4: J9.4 R62.2 | length 4.8
  Top Layer w0.254: J9.4@26.579,121.092 26.575,121.088 26.575,119.153 27.45,118.278 ; R62.2@27.461,116.685 27.461,118.262
NetJ10_5: J10.5 R66.2 | length 4.4
  Top Layer w0.254: R66.2@24.917,90.689 27.229,88.378 J10.5@27.229,87.249
NetJ10_7: J10.7 R67.2 | length 4.4
  Top Layer w0.254: R67.2@22.37,90.688 24.689,88.369 J10.7@24.689,87.249
NetJ11_1: J11.1 L1.1 | length 5.8
  Top Layer w0.254: L1.1@31.905,119.756 35.978,119.756 36.441,120.219 J11.1@36.441,121.322
NetJ11_5: J11.5 L2.1 | length 3.2
  Top Layer w0.254: J11.5@39.041,121.322 39.041,118.907 L2.1@39.604,118.344
NetJ16_1: J16.1 R79.1 R84.2 | length 4.4
  Top Layer w0.254: J16.1@76.657,83.287 76.751,83.38 76.751,86.208 76.852,86.106 R79.1@78.088,86.106 ; R79.1@78.088,86.233 R79.1@78.113,86.233
NetJ17_1: J17.1 R80.1 R85.2 | length 4.3
  Top Layer w0.254: J17.1@77.114,68.595 77.265,68.445 77.265,65.684 R80.1@78.545,65.684
NetJ18_1: J18.1 R81.1 R86.2 | length 4.3
  Top Layer w0.254: J18.1@77.219,72.23 77.219,73.714 77.487,73.982 77.487,75.082 78.826,75.082 R81.1@78.85,75.106
NetJ20_1: J20.1 R82.1 R87.2 | length 4.3
  Top Layer w0.254: J20.1@77.241,79.197 77.241,77.799 77.513,77.527 77.513,76.286 R82.1@78.832,76.286
NetJ27_2: J27.2 S1.1 | length 4.4
  Top Layer w0.254: S1.1@43.151,62.372 43.151,63.116 44.704,64.668 J27.2@44.704,66.091
NetQ1_2: Q1.2 R118.2 | length 3.3
  Top Layer w0.254: R118.2@69.435,116.551 69.473,116.588 Q1.2@72.763,116.588
NetTP1_1: TP1.1 U1.17 | length 8.9
  Top Layer w0.254: TP1.1@8.071,44.737 8.091,44.717 9.614,44.717 9.643,44.717 12.276,47.35 U1.17@15.847,47.35
NetTP2_1: TP2.1 U1.18 | length 7.6
  Top Layer w0.254: TP2.1@9.872,43.688 9.872,44.162 12.56,46.85 U1.18@15.847,46.85
NetTP3_1: TP3.1 U1.19 | length 9.3
  Top Layer w0.254: TP3.1@8.133,42.748 9.639,42.748 10.574,43.684 10.574,43.848 13.076,46.35 U1.19@15.847,46.35
NetTP4_1: TP4.1 U1.20 | length 8
  Top Layer w0.254: TP4.1@9.906,41.808 11.472,43.374 11.472,44.104 13.218,45.85 U1.20@15.847,45.85
NetTP5_1: TP5.1 U1.21 | length 10.2
  Top Layer w0.254: TP5.1@8.122,40.75 9.889,40.75 12.295,43.156 12.295,44.157 13.488,45.35 U1.21@15.847,45.35
NetTP6_1: TP6.1 U1.42 | length 3.3
  Top Layer w0.254: U1.42@25.572,41.625 25.572,39.446 26.226,38.792 TP6.1@26.226,38.625
NetTP7_1: TP7.1 U1.44 | length 5.2
  Top Layer w0.254: U1.44@26.572,41.625 26.572,39.747 26.975,39.345 26.975,37.902 TP7.1@27.889,36.987
NetTP8_1: TP8.1 U1.45 | length 3.3
  Top Layer w0.254: U1.45@27.072,41.625 27.072,40.356 27.829,39.599 27.829,38.609 TP8.1@27.838,38.6
NetTP9_1: TP9.1 U1.46 | length 4
  Top Layer w0.254: U1.46@27.572,41.625 27.572,40.602 29.6,38.575 TP9.1@29.667,38.575
NetTP10_1: TP10.1 U1.55 | length 3
  Top Layer w0.254: U1.55@31.297,45.35 34.031,45.35 TP10.1@34.239,45.558
NetTP11_1: TP11.1 U1.56 | length 4.1
  Top Layer w0.254: U1.56@31.297,45.85 33.454,45.85 TP11.1@34.812,47.208
NetTP12_1: TP12.1 U1.57 | length 2.5
  Top Layer w0.254: U1.57@31.297,46.35 32.231,46.35 TP12.1@33.312,47.43
NetTP13_1: TP13.1 U1.2 | length 14.6
  Top Layer w0.254: TP13.1@13.865,67.842 13.865,55.423 14.438,54.85 U1.2@15.847,54.85
NetTP14_1: TP14.1 U1.16 | length 5.7
  Top Layer w0.254: TP14.1@10.262,48.108 10.52,47.85 U1.16@15.847,47.85
NetTP16_1: TP16.1 U1.88 | length 7.1
  Top Layer w0.254: U1.88@23.572,57.075 23.572,58.7 24.968,60.096 TP16.1@24.968,63.602
NetTP18_1: TP18.1 U1.68 | length 5.2
  Top Layer w0.254: U1.68@31.297,51.85 34.268,51.85 34.456,51.661 35.038,51.661 35.227,51.85 36.353,51.85 TP18.1@36.359,51.856
NetTP19_1: TP19.1 U1.69 | length 3.5
  Top Layer w0.254: U1.69@31.297,52.35 34.734,52.35 TP19.1@34.747,52.363
NetTP20_1: TP20.1 U1.70 | length 5.3
  Top Layer w0.254: U1.70@31.297,52.85 33.139,52.85 33.401,53.111 36.016,53.111 TP20.1@36.373,53.468
NetTP21_1: TP21.1 U1.71 | length 3.7
  Top Layer w0.254: U1.71@31.297,53.35 32.92,53.35 33.546,53.975 TP21.1@34.747,53.975
NetTP22_1: TP22.1 U1.72 | length 5.6
  Top Layer w0.254: U1.72@31.297,53.85 32.677,53.85 33.908,55.081 TP22.1@36.424,55.081
NetTP23_1: TP23.1 U1.73 | length 4.1
  Top Layer w0.254: U1.73@31.297,54.35 32.535,54.35 34.073,55.887 TP23.1@34.747,55.887
NetTP24_1: TP24.1 U1.74 | length 5.8
  Top Layer w0.254: U1.74@31.297,54.85 32.282,54.85 34.126,56.693 TP24.1@36.373,56.693
NetTP26_1: TP26.1 U1.75 | length 4.3
  Top Layer w0.254: U1.75@31.297,55.35 32.14,55.35 34.29,57.5 TP26.1@34.714,57.5
nFAULT: J4.2 R6.1 R83.1 R112.1 U7.26 | length 103.6
  Top Layer w0.254: J4.2@66.464,91.363 68.986,91.363 69.443,90.907 70.918,90.907 70.969,90.856 ; R112.1@74.56,90.856 70.969,90.856 ; R6.1@79.09,20.864 v1@80.198,20.864 ; v1(87.833,73.838) 87.205,74.466 87.205,77.895 81.686,83.414 81.686,87.401 80.036,89.052 72.005,89.052 70.988,90.068 70.995,90.075 70.995,90.83 70.969,90.856 ; v1@87.986,73.99 89.891,72.085 89.891,70.598 90.221,70.268 R83.1@90.907,70.268 91.053,70.121 U7.26@94.689,70.121
  Bottom Layer w0.254: v1(80.249,20.853) 80,21.102 80,64.135 87.833,71.968 v1(87.833,73.838)
nHOME/OCPM: J4.4 R9.1 R88.1 U7.27 | length 142.7
  Top Layer w0.254: R9.1@36.84,2.889 38.71,2.889 43.155,7.334 43.155,9.601 v1(59.512,25.959) ; J4.4@66.464,88.823 69.85,88.823 ; 69.825,88.798 69.85,88.823 ; U7.27@94.689,69.486 89.315,69.486 88.875,69.926 R88.1@88.875,70.248 88.172,70.248 87.389,71.031 87.389,73.195 86.752,73.833 86.752,77.521 81.208,83.065 81.208,86.893 80.195,87.906 70.768,87.906 69.85,88.823
  Bottom Layer w0.254: v1@59.538,25.959 59.538,40.767 59.182,41.123 67.005,48.946 67.005,63.896 67.784,64.675 67.784,85.135 70.685,88.036 v1(70.714,88.036)
nSCS/M0/EN4/VREF1/VREF: J25.1 J26.1 R23.1 U7.34 | length 97.6
  Top Layer w0.254: R23.1@36.72,23.495 40.53,23.495 58.608,41.573 63.207,41.573 63.631,41.148 v1(64.008,41.148) ; J25.1@65.345,69.926 69.418,69.926 J26.1@69.444,69.901 ; v1(69.24,64.251) 69.24,64.206 70.099,63.348 89.256,63.348 89.265,63.338 90.967,65.041 U7.34@94.689,65.041
  Bottom Layer w0.254: v1(64.008,41.148) 64.008,41.707 68.174,45.872 68.174,63.184 v1(69.24,64.251) 70.596,65.606 70.596,67.838 70.13,68.303 v1(70.13,68.595) 69.444,69.282 J26.1@69.444,69.901
nSLEEP: J8.16 R34.1 U7.42 | length 82.5
  Top Layer w0.254: R34.1@36.84,10.689 39.98,10.689 66.473,37.182 J8.16@66.473,44.323 75.85,44.323 75.87,44.304 91.527,59.961 U7.42@94.689,59.961
PUSH: J27.3
RST/SBWTDIO: C74.1 J3.11 J10.4 J27.1 R29.2 U1.96 | length 75.6
  Top Layer w0.254: U1.96@19.572,57.075 19.572,58.909 19.851,59.188 19.851,59.228 22.032,61.409 22.032,64.111 24.232,66.311 41.944,66.311 J27.1@42.164,66.091 40.799,64.726 C74.1@37.804,64.726
  Bottom Layer w0.254: J3.11@19.38,79.28 19.38,80.569 20.117,81.305 22.76,81.305 23.368,81.914 23.368,85.277 23.952,85.861 23.952,85.928 28.042,85.928 29.26,84.709 J10.4@29.769,84.709 30.938,83.541 33.122,83.541 42.164,74.498 J27.1@42.164,66.091
RSVD/IPROPI1/IPROPI2/IPROPI: J4.14 J17.2 R21.1 R80.2 U7.32 | length 94.2
  Top Layer w0.254: R21.1@65.09,14.992 v1@65.09,16.17 ; J4.14@66.464,76.123 69.977,76.123 ; 69.977,76.048 70.231,76.048 76.302,69.977 78.272,69.977 J17.2@79.654,68.595 79.654,67.242 79.545,67.132 R80.2@79.545,65.684 86.995,65.684 87.622,66.311 U7.32@94.689,66.311
  Bottom Layer w0.254: v1(65.075,16.231) 65.075,17.728 71.45,24.103 71.45,38.532 75.675,42.757 75.675,63.057 79.654,67.036 J17.2@79.654,68.595
RSVD/IPROPI2/IPROPI1/IPROPI: J4.12 J18.2 J19.2 R18.1 R81.2 U7.31 | length 102.4
  Top Layer w0.254: v1@65.1,19.126 65.115,19.112 R18.1@65.115,17.939 ; J4.12@66.464,78.663 70.002,78.663 74.778,73.888 74.778,72.19 76.301,70.666 78.195,70.666 J18.2@79.759,72.23 79.777,72.212 80.797,72.212 80.797,72.136 85.987,66.946 U7.31@94.689,66.946 ; J18.2@79.85,72.321 79.85,73.584 ; R81.2@79.85,75.106 79.85,73.584 ; J19.2@83.408,73.521 79.912,73.521 79.85,73.584
  Bottom Layer w0.254: v1(65.129,19.152) 65.557,19.152 70.891,24.486 70.891,39.016 75.006,43.131 75.006,63.284 78.446,66.724 78.446,70.916 J18.2@79.759,72.23
RSVD/IPROPI3: J4.10 J19.1 J20.2 R17.1 R82.2 U7.30 | length 104.7
  Top Layer w0.254: R17.1@65.09,20.921 64.033,21.978 64.033,29.962 75.133,41.062 v1(75.133,41.097) ; J4.10@66.464,81.203 66.617,81.356 71.697,81.356 72.552,80.502 78.477,80.502 J20.2@79.781,79.197 79.832,79.146 R82.2@79.832,76.286 J19.1@83.183,76.286 ; J19.1@83.259,76.54 85.268,74.532 85.268,70.415 88.102,67.581 U7.30@94.689,67.581
  Bottom Layer w0.254: v1@75.133,41.062 76.183,42.198 76.183,62.459 81.407,67.682 81.407,77.572 J20.2@79.781,79.197
RSVD/TOFF/EN3: J8.2 R24.1 U7.35 | length 102.9
  Top Layer w0.254: R24.1@36.865,5.549 39.257,5.549 42.229,8.52 42.229,9.747 70.714,38.232 70.714,40.97 v1@70.815,41.072 ; J8.2@66.473,62.103 88.671,62.103 90.974,64.406 U7.35@94.689,64.406
  Bottom Layer w0.254: v1(70.714,41.097) 71.091,41.097 74.244,44.25 v1(74.244,62.128)
RX: R70.1 U4.5 | length 2.7
  Top Layer w0.254: R70.1@43.805,113.383 46.444,113.383 U4.5@46.468,113.36
SCLK/M1/IN4/RSVD: J8.8 R27.1 U7.38 | length 69.4
  Top Layer w0.254: J8.8@66.473,54.483 66.531,54.424 v1(79.223,54.424) 83.108,54.424 83.167,54.483 91.185,62.501 U7.38@94.689,62.501 ; R27.1@79.09,18.139 79.093,18.136 v1@80.188,18.136
  Bottom Layer w0.254: v1(79.223,54.424) 79.223,30.429 79.223,19.187 v1(80.249,18.161)
SDI/DECAY0/EN1/DECAY: J8.6 R26.1 U7.37 | length 90.8
  Top Layer w0.254: R26.1@36.712,15.578 42.934,15.578 65.405,38.049 v1@65.405,41.097 ; J8.6@66.473,57.023 84.97,57.023 91.025,63.078 91.025,63.136 U7.37@94.689,63.136
  Bottom Layer w0.254: v1(65.43,41.148) 66.777,41.148 70.917,45.288 v1(70.917,57.074)
SDO/DECAY1/EN2/RSVD: J8.4 R25.1 U7.36 | length 87.4
  Top Layer w0.254: R25.1@36.695,20.726 40.437,20.726 v1(60.706,40.996) ; J8.4@66.473,59.563 86.809,59.563 91.018,63.771 U7.36@94.689,63.771
  Bottom Layer w0.254: v1(60.706,40.996) 61.214,40.996 61.9,40.31 64.062,40.31 64.621,40.869 64.621,41.271 68.972,45.622 69.037,45.622 v1(69.037,59.639)
STEP/IN3/RSVD: J8.10 R30.1 U7.39 | length 77.6
  Top Layer w0.254: R30.1@36.771,25.806 38.43,25.806 54.788,42.164 62.951,42.164 63.246,42.164 64.059,42.977 64.059,51.003 64.999,51.943 J8.10@66.473,51.943 81.444,51.943 91.367,61.866 U7.39@94.689,61.866
T_RST_RST: R65.1 U2.43 | length 9.7
  Top Layer w0.254: 27.663,99.081 27.361,99.383 29.57,97.175 29.57,94.86 28.282,93.573 R65.1@28.282,91.536
T_TEST_TCKC: R64.1 U2.44 | length 9.5
  Top Layer w0.254: U2.44@27.715,99.737 30.185,97.267 30.185,92.951 30.806,92.33 R64.1@30.806,91.536
TB0CLK: U1.43 U1.58 | length 8.3
  Top Layer w0.254: U1.43@26.072,41.625 26.072,43.116 29.805,46.85 U1.58@31.297,46.85
TCK: J3.7 U1.95 | length 24
  Top Layer w0.254: U1.95@20.072,57.075 20.072,58.35 v1(20.396,58.674)
  Bottom Layer w0.254: v1(20.396,58.674) 20.396,70.536 23.089,73.228 23.089,77.908 J3.7@24.46,79.28
TDI: J3.3 U1.93 | length 26.8
  Top Layer w0.254: U1.93@21.072,57.075 v1(21.072,59.411)
  Bottom Layer w0.254: v1(21.072,59.411) 21.488,59.827 21.488,70.612 25.781,74.905 25.781,77.419 26.506,78.145 26.523,78.128 28.388,78.128 J3.3@29.54,79.28
TDO: J3.1 U1.92 | length 32.4
  Top Layer w0.254: v1@21.572,55.329 U1.92@21.572,57.075
  Bottom Layer w0.254: v1(21.615,55.397) 22.217,55.974 22.217,57.836 21.742,58.311 21.742,59.055 22.217,59.53 22.217,70.68 26.543,75.006 29.956,75.006 30.836,75.885 30.836,78.035 J3.1@32.08,79.28
TMS: J3.5 U1.94 | length 33.5
  Top Layer w0.254: v1@20.422,55.245 20.572,55.396 U1.94@20.572,57.075
  Bottom Layer w0.254: v1@20.422,55.245 19.761,55.905 19.761,70.859 20.574,71.671 20.574,77.318 21.285,78.029 22.455,78.029 23.254,78.828 23.254,79.871 23.901,80.518 25.762,80.518 J3.5@27,79.28
  other v1: 20.371,55.296
TST/SBWTCK: J3.8 J10.2 U1.91 | length 48.1
  Top Layer w0.254: U1.91@22.072,57.075 22.072,55.757 22.192,55.636 22.192,55.612 v1@22.657,55.148 ; J3.8@24.46,76.74 25.848,78.128 25.848,79.757 27.6,81.509 v1(32.299,81.509) ; v1@32.297,81.566 32.297,84.709 J10.2@32.309,84.709
  Bottom Layer w0.254: v1(22.672,55.143) 23.58,55.143 33.661,65.224 33.661,80.146 v1(32.299,81.509)
TX: R69.2 U4.1 | length 2.7
  Top Layer w0.254: R69.2@43.773,116.053 43.866,115.96 U4.1@46.468,115.96
USB_D_N: J11.2 R72.1 R73.1 U6.2 U6.6 | length 24.5
  Top Layer w0.254: v1(36.207,118.821) 36.318,118.933 U6.6@37.009,118.933 37.032,118.956 37.032,121.263 J11.2@37.091,121.322 ; U6.2@37.501,118.339 37.501,116.856 v1(36.748,116.103) 37.616,115.236 R72.1@37.616,113.035 ; v1(38.989,115.519) 39.381,115.519 41.447,113.453 41.447,111.865 42.428,110.884 R73.1@42.428,107.344
  Bottom Layer w0.254: v1(36.207,118.821) 36.207,116.645 v1(36.748,116.103) 38.405,116.103 v1(38.989,115.519)
USB_D_P: J11.3 R71.1 R75.1 U6.3 | length 18.3
  Top Layer w0.254: J11.3@37.741,121.322 37.839,121.224 37.839,120.526 38.486,119.879 38.486,118.656 38.235,118.406 38.009,118.406 U6.3@38.009,118.333 38.412,117.929 38.412,115.28 38.846,114.846 R75.1@38.846,113.035 38.846,112.562 39.282,112.562 40.791,111.053 40.791,107.366 R71.1@42.412,105.745
VM: C44.1 C51.1 C53.2 C54.1 C55.1 C56.1 C57.1 C58.1 C59.1 D4.2 F1.1 J23.2 R97.2 R98.2 TP30.1 U5.10 U7.2 U7.11 U7.12 U7.21 | length 191.8
  Top Layer w0.254: U5.10@46.997,100.853 52.228,100.853 C44.1@52.391,100.69 83.782,100.69 C53.2@85.836,98.635 ; R97.2@78.363,118.591 78.563,118.391 D4.2@78.563,116.901 ; TP30.1@81.75,120 81.86,120.11 91.92,120.11 91.92,118.35 91.92,109.95 85.927,103.957 C53.2@85.927,98.635 ; C53.2@85.807,98.635 C53.2@85.836,98.635 ; v1@90.399,100.831 90.402,100.295 90.406,99.753 90.409,99.204 v1@90.413,98.629 ; v1@90.432,95.783 90.431,95.885 90.427,96.444 90.427,96.459 v1(90.424,96.977) 90.424,96.992 90.42,97.525 90.417,98.088 v1@90.413,98.629 ; v1@91.135,98.628 v1@90.413,98.629 ; v1(91.161,100.863) 91.162,100.32 91.163,99.787 91.165,99.223 91.166,98.628 91.168,98.08 91.169,97.55 91.171,96.991 91.171,96.977 91.172,96.458 91.172,96.444 91.173,95.91 v1@91.173,95.86 ; U7.2@101.886,59.33 101.915,59.301 102.938,59.301 104.104,58.135 v1(104.104,57.912) ; U7.11@102.189,65.041 102.207,65.024 v1(103.607,65.024) 103.634,65.051 v1(104.292,65.051) 105.463,65.051 C57.1@105.817,65.405 105.512,65.71 v1(104.256,65.71) 104.241,65.695 v1(103.607,65.695) 103.588,65.676 U7.12@102.189,65.676 ; U7.21@102.189,71.391 103.539,71.391 v1(103.632,71.298) 104.291,71.298 v1(104.318,71.325) ; v1(103.454,57.897) 104.089,57.897 v1(104.104,57.912) ; C51.1@103.594,56.083 103.454,56.223 v1(103.454,57.226) 103.481,57.253 v1(104.14,57.253) ; v1(103.632,71.969) 103.647,71.984 v1(104.282,71.984) 104.51,72.212 C59.1@105.288,72.212 ; R98.2@109.855,11.002 109.855,37.527 104.071,43.311 104.113,43.353 104.113,49.756 105.598,51.241 C56.1@105.598,53.569 105.588,53.579 C58.1@105.588,57.236 104.157,57.236 v1(104.14,57.253) ; C53.2@85.836,98.635 85.927,98.545 C53.2@85.927,98.635 ; C53.2@85.836,98.635 C53.2@85.927,98.635 ; C53.2@85.927,98.635 v1(90.399,98.628) v1@90.413,98.629 ; v1(104.104,57.912) 104.104,57.29 v1(104.14,57.253)
  Top Layer w2.54: 85.927,95.09 C53.2@85.927,98.545 ; 91.186,118.391 91.227,118.35 91.92,118.35 ; v4(105.288,88.387) 105.288,92.358 F1.1@107.645,94.715 109.047,94.715 J23.2@119.127,104.796
  Bottom Layer w0.254: C54.1@78.48,109.155 80.124,109.155 80.23,109.261 v1(80.296,109.261) 80.249,109.214 80.249,108.851 78.563,107.164 C55.1@78.49,107.164 ; TP30.1@81.75,120 TP30.1@81.86,120.11
  other v1: 90.424,95.885 91.175,95.91 90.424,96.444 91.175,96.444 91.175,96.977 90.424,97.511 91.175,97.536 90.399,98.069 91.186,98.069 91.186,98.628 90.399,99.187 91.186,99.212 90.399,99.737 91.161,99.771 90.399,100.279 91.161,100.305 90.399,100.838
VREF/VREF2: J5.1 J6.1 J7.1 J25.2 U7.33 | length 49.6
  Top Layer w0.254: J25.2@62.805,69.926 J6.1@58.445,69.926 J7.1@58.445,66.371 58.445,66.209 70.122,66.209 71.734,67.821 71.734,68.667 J5.1@73,69.933 74.441,68.491 74.441,66.245 75.629,65.057 87.01,65.057 87.633,65.68 U7.33@94.386,65.68
VSEN_AOUT1: C67.1 R5.1 R7.1 R89.1 R93.2 | length 6.4
  Top Layer w0.254: R5.1@117.083,37.641 R7.1@118.43,37.641 ; R7.1@118.582,37.649 118.613,37.679 C67.1@120.218,37.679 120.636,38.097 R93.2@122.002,38.097 ; R93.2@122.352,38.076 R89.1@122.352,39.531
VSEN_AOUT2: C68.1 R8.1 R10.1 R90.1 R94.2 | length 7.2
  Top Layer w0.254: R8.1@117.26,30.072 R10.1@118.608,30.072 118.671,30.009 C68.1@120.309,30.009 122.129,30.009 R94.2@122.152,30.032 122.129,30.055 R90.1@122.129,32.282
VSEN_BOUT1: C69.1 R12.1 R13.1 R91.1 R95.2 | length 7.1
  Top Layer w0.254: R13.1@117.297,22.866 R12.1@118.531,22.866 118.612,22.785 C69.1@120.139,22.785 121.033,22.785 121.329,23.082 R95.2@122.389,23.082 R91.1@122.389,24.932
VSEN_BOUT2: C70.1 R15.1 R16.1 R92.1 R96.2 | length 6.7
  Top Layer w0.254: R16.1@117.507,15.025 117.604,15.122 R15.1@118.701,15.122 118.858,15.28 C70.1@120.367,15.28 120.442,15.356 R96.2@122.377,15.356 122.404,15.382 R92.1@122.404,17.055