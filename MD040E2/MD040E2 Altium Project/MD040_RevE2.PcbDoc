# Altium PCB MD040_RevE2.PcbDoc (part 5 of 5)
Units mm, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 127 x 127 mm, 4 copper layers (Top Layer, Signal Layer 1, Signal Layer 2, Bottom Layer), stack 1.554 mm thick; 336 components, 206 nets, 924 pads, 303 vias.
Unrouted connection lines stored in the file: 125.

## Via types
v1: diameter 0.5, hole 0.35, Top Layer to Bottom Layer, tented both sides, 210 vias
v2: diameter 0.5, hole 0.2, Top Layer to Bottom Layer, tented both sides, 65 vias
v3: diameter 0.5, hole 0.2, Top Layer to Bottom Layer, 22 vias
v4: diameter 3.6, hole 3.6, Top Layer to Bottom Layer, tented both sides, 5 vias
v5: diameter 0.5, hole 0.35, Top Layer to Bottom Layer, tented bottom, 1 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
VSEN_VM: C71.1 J1.3 R98.1 R104.2 TP37.1 U1.1 | length 118.3
  Top Layer w0.254: U1.1@15.847,55.35 16.786,55.35 25.298,46.838 v1(25.298,46.38) ; J1.3@75.36,5.549 78.537,5.549 80.354,7.366 85.954,7.366 87.249,8.661 TP37.1@89.165,8.661 91.244,8.661 92.151,7.754 C71.1@107.824,7.754 108.639,7.754 109.006,8.121 R104.2@109.861,8.121 109.855,8.128 R98.1@109.855,9.602
  Bottom Layer w0.254: v1(25.298,46.38) 25.298,46.278 29.217,42.36 36.177,42.36 71.603,6.934 73.279,6.934 74.665,5.549 J1.3@75.36,5.549
pads on no net: FID1.1 FID2.1 FID3.1 H1.0 H2.0 H3.0 H4.0 J1.2 J1.5 J1.7 J1.11 J1.17 J1.19 J2.6 J2.8 J2.9 J2.10 J2.11 J2.15 J2.16 J2.17 J2.19 J3.6 J3.10 J3.12 J3.13 J3.14 J9.6 J9.10 J9.12 J9.13 J9.14 J10.11 J10.12 J11.4 J15.2 J21.2 LBL1.0 S1.2 SH-J1.0 SH-J2.0 SH-J3.0 SH-J4.0 SH-J5.0 SH-J6.0 SH-J7.0 SH-J8.0 SH-J9.0 SH-J10.0 SH-J11.0 SH-J12.0 SH-J13.0 SH-J14.0 SH-J15.0 SH-J16.0 SH-J17.0 SH-J18.0 SH-J19.0 SH-J20.0 SH-J21.0 SH-J22.0 SH-J23.0 SH-J24.0 SH-J25.0 SH-J26.0 SH-J27.0 SH-J28.0 SH-J29.0 SH-J30.0 SH-J31.0 U1.28 U1.30 U1.47 U1.48 U1.49 U1.77 U1.78 U1.79 U1.80 U1.81 U1.82 U1.86 U2.3 U2.4 U2.5 U2.6 U2.7 U2.8 U2.10 U2.12 U2.13 U2.18 U2.19 U2.22 U2.23 U2.24 U2.25 U2.26 U2.27 U2.28 U2.29 U2.30 U2.31 U2.32 U2.33 U2.34 U2.35 U2.36 U2.41 U2.42 U2.45 U2.46 U2.47 U2.48 U3.2 U3.6 U3.7 U4.2 U4.3 U4.6 U4.8 U4.9 U4.10 U4.11 U4.12 U4.13 U4.14 U4.19 U4.22 U4.23 U4.24 U4.27 U4.28 U5.3 U5.6 U5.9 U6.5
copper on no net: | length 15.6
  Top Layer w0.254: 101.886,58.695 102.094,58.486 102.094,56.083
  Signal Layer 2 w0.254: 68.859,62.052 70.51,62.052 70.561,62.103 ; 70.714,46.838 70.714,46.863
  Bottom Layer w0.254: 58.649,42.342 66.551,50.244
  other v4: 6.5,6.5 120.5,6.5 6.5,120.5 120.5,120.5

## Polygon pours and split planes (outlines as drawn)
GND on Signal Layer 1 "SIGNAL_LAYER_1_GND_P184" (solid, pour order 184): 0,127 127,127 127,71.247 127,23.647 127,0 39.5,0 -0.305,0
EZFET_VBUS on Signal Layer 2 "SIGNAL_LAYER_2_EZFET_VBUS_P136" (solid, remove dead copper, pour order 136): 30.345,126.991 46.212,126.991 46.212,113.172 30.38,113.172
GND on Signal Layer 2 "SIGNAL_LAYER_2_GND_P199" (solid, pour order 199): 0,0 127,0 127,127 0,127
GND on Bottom Layer "BOTTOM_LAYER_GND_P258" (solid, remove dead copper, pour order 258): 0,0 127,0 127,127 0,127
EZFET_USB_Shield on Bottom Layer "BOTTOM_LAYER_EZFET_USB_SHIELD_P219" (solid, remove dead copper, pour order 219): 23.754,102.06 35.846,102.06 35.846,96.78 23.754,96.78
GND on Top Layer "TOP_LAYER_GND_P237" (solid, remove dead copper, pour order 237): 0,0 127,0 127,127 0,127
AOUT2/OUT2 on Top Layer "Top Layer-AOUT2" (solid, pour order 248): 101.473,63.976 108.45,63.983 110.463,65.995 118.466,65.995 119.527,67.056 126.632,67.056 126.644,67.044 126.644,56.921 117.661,56.921 116.924,57.658 113.792,57.15 108.818,62.332 101.473,62.332
AOUT1/OUT1 on Top Layer "Top Layer-AOUT1" (solid, pour order 250): 101.448,62.078 107.518,62.078 112.141,57.455 116.789,57.455 117.577,56.667 126.644,56.667 126.644,46.337 126.612,46.304 111.398,46.304 106.709,50.993 106.709,59.33 105.613,60.427 105.588,60.401 101.448,60.401
VM on Top Layer "TOP_LAYER_VM_P244" (solid, pour order 244): 101.473,65.87 101.508,65.905 106.324,65.905 106.324,64.846 101.473,64.846
BOUT2/OUT4 on Top Layer "TOP_LAYER_BOUT2/OUT4_P242" (solid, pour order 242): 101.473,68.428 107.593,68.428 110.49,71.325 110.49,75.336 111.404,76.251 116.84,76.251 118.415,77.826 126.644,77.826 126.492,77.673 126.492,67.31 119.228,67.31 118.329,66.411 109.103,66.411 108.763,66.751 101.473,66.751
BOUT1/OUT3 on Top Layer "TOP_LAYER_BOUT1/OUT3_P240" (solid, pour order 240): 101.473,68.656 107.371,68.656 110.312,71.603 110.312,76.53 117.701,78.054 126.891,78.054 126.891,87.87 126.854,87.833 110.515,87.833 105.893,83.21 105.893,72.314 103.632,70.333 101.473,70.333
VM on Top Layer "TOP_LAYER_VM_P239" (solid, pour order 239): 52.9,47.1 56.1,47.1 56.1,43.7
EZFET_USB_Shield on Top Layer "TOP_LAYER_EZFET_USB_SHIELD_P201" (solid, remove dead copper, pour order 201): 23.708,102.06 35.8,102.06 35.8,96.78 23.708,96.78

## Keep-outs
Keep-Out Layer:
  circle w0.254: c120.5,6.5 r3
  circle w0.254: c6.5,6.5 r3
  circle w0.254: c120.5,120.5 r3
  circle w0.254: c6.5,120.5 r3
  text ".Layer_Name" at 14.656,-21.806 h1.52

## Other copper
Top Layer:
  region net AOUT1/OUT1: 101.117,62.078 101.143,62.103 108.274,62.078 113.699,56.652 114.021,56.652 125.857,56.652 125.857,56.261 125.832,56.236 125.832,48.438 125.349,47.955 114.529,47.955 106.959,55.524 106.959,56.286 106.594,56.652 106.594,59.649 106.161,59.965 104.195,59.965 103.734,60.427 101.092,60.427 101.067,60.452 101.067,62.128
  region net VM: 77.826,126.848 78.08,127.102 93.751,127.102 93.751,107.061 91.542,104.851 91.542,94.437 90.399,93.294 82.118,93.294 77.953,97.726 77.953,127.152
  region net EZFET_USB_Shield: 32.334,126.345 32.334,126.257 32.334,120.675 35.923,120.675 35.923,122.426 36.347,122.758 36.497,122.758 39.105,122.758 39.474,122.389 39.474,122.166 39.474,120.81 39.607,120.81 40.882,120.81 40.882,120.848 40.882,122.19 42.627,122.19 43.332,122.896 43.307,126.333 43.119,126.333
  region net BOUT1/OUT3: 101.194,68.682 101.194,70.307 101.219,70.282 102.794,70.307 103.124,70.79 105.918,70.79 106.252,71.124 106.252,81.89 118.648,94.285 126.086,94.361 126.162,94.285 126.162,80.721 125.247,80.721 114.859,80.721 114.09,79.953 114.09,74.644 113.057,73.33 112.459,72.568 109.388,68.656 101.143,68.656 101.117,68.682
  region net BOUT2/OUT4: 101.236,66.777 101.236,68.402 109.626,68.402 114.471,74.694 114.441,79.945 114.91,80.34 126.086,80.34 126.162,80.416 126.162,68.504 120.961,68.498 119.678,67.215 118.237,67.215 118.237,68.922 116.808,68.922 116.84,66.345 116.281,65.735 108.636,65.735 108.636,66.167 108.56,66.167 107.975,66.751 101.246,66.751 101.219,66.724
  region net AOUT2/OUT2: 101.194,63.957 101.168,63.932 101.168,62.332 109.83,62.332 113.792,57.15 126.06,57.15 126.136,57.074 126.136,68.047 121.641,68.047 119.761,66.167 118.262,66.167 118.262,64.745 118.033,64.515 117.551,64.515 116.739,64.515 116.23,65.024 108.61,65.024 108.61,64.364 108.204,63.957 101.219,63.957 101.194,63.983
  region net VM: 101.168,71.583 102.616,71.577 103.022,71.984 103.022,72.593 103.276,72.847 105.593,72.847 105.651,72.852 105.794,72.71 105.794,71.069 102.87,71.069 102.743,71.196 101.168,71.196
  region net VM: 101.168,65.888 101.186,65.905 106.324,65.905 106.324,64.846 101.168,64.846
  region net VM: 101.651,59.131 101.651,59.538 103.226,59.538 104.917,57.846 106.248,57.846 106.248,55.408 102.844,55.408 102.844,59.03 102.743,59.131
  text ".Layer_Name" at 14.656,-21.806 h1.52
Signal Layer 2:
  region net VM: 77.521,126.162 93.751,126.162 93.751,99.873 107.925,89.419 107.925,55.637 102.173,55.637 101.117,56.693 101.117,73.711 100.33,74.498 100.33,74.6 77.419,97.511 77.419,126.035
Bottom Layer:
  region net EZFET_USB_Shield: 32.106,126.362 32.106,121.848 32.862,121.092 44.08,121.092 44.983,121.996 44.983,126.362 32.136,126.362 32.113,126.34
  region net GND: 94.005,75.565 101.473,75.565 101.524,75.616 101.524,72.898 101.27,72.644 100.982,72.644 100.817,72.479 100.891,57.917 101.246,57.607 101.223,57.584 101.223,55.55 94.853,55.55 94.853,57.917 95.25,58.314 95.25,58.831 95.25,72.695 94.691,72.695 93.98,73.406 93.98,75.641
  text ".Layer_Name" at 14.656,-21.806 h1.52

## Silkscreen, mask and mechanical layers (free items; w line width, h text height)
Top Overlay:
  lines w0.152: 2.711,68.435 2.711,66.1 7.91,60.587 ; 4.47,21.463 22.466,21.463 ; 4.496,15.951 22.581,15.951 ; 7.098,10.16 7.098,26.746 ; 10.287,10.185 10.287,26.746 ; 13.513,10.16 13.513,26.746 ; 16.662,10.211 16.662,26.746 ; 19.71,10.16 19.71,26.619
  lines w0.2: 23.927,37.008 23.951,1.682 23.952,0.178 ; 31.672,42.25 81.137,42.276 81.407,0.051
  lines w0.254: 4.47,10.16 22.555,10.16 22.555,26.746 4.47,26.746 4.47,10.16
  text "GND" at 71.396,124.362 h1.52
  text "VIN" at 80.25,123.5 h1.52
  text "GND" at 110.561,123.5 h1.52
  text "VIN" at 67.488,114.452 h1.52
  text "1" at 22.098,107.894 h0.6
  text "For EZFET-LITE Flashing Only" at 4.9,97.155 h1
  text "nFAULT" at 68.555,91.046 h1.52
  text "GND" at 6.248,90.246 h1.52 r90
  text "3V3" at 42.951,89.891 h1.52
  text "BOUT1" at 121.158,89.205 h1.52 r90
  text "OUT4" at 125.197,89.129 h1.52 r90
  text "nHOME/OCPM" at 68.555,88.595 h1
  text "MODE/MODE1" at 68.555,85.877 h1
  text "MODE2/IPROPI4" at 68.529,83.445 h1
  text "RSVD/IPROPI3" at 68.707,80.797 h1
  text "VM" at 102.254,78.212 h1
  text "RSVD/IPROPI2/ / IPROPI1/IPROPI" at 68.555,77.927 h1
  text "RSVD/IPROPI1/ / IPROPI2/IPROPI" at 68.597,75.362 h1
  text "M0/nSCS/" at 68.656,73.482 h1
  text "VREF1/EN4" at 68.656,72.535 h1
  text "OUT3" at 125.197,69.19 h1.52 r90
  text "Torque Count" at 3.04,68.954 h1.02 r90
  text "BOUT2" at 120.726,68.885 h1.52 r90
  text "ID4" at 31.166,67.285 h1.52
  text "ID5" at 28.626,67.234 h1.52
  text "RST" at 39.853,63.856 h1.02
  text "PUSH" at 46.66,63.805 h1.02
  text "AOUT2" at 120.802,63.17 h1.52 r90
  text "OUT2" at 125.197,63.094 h1.52 r90
  text "RSVD/TOFF/EN3" at 68.532,61.57 h1.52
  text "SDO/DECAY1/EN2/RSVD" at 68.631,59.131 h1.52
  text "SDI/DECAY0/EN1/DECAY" at 68.631,56.49 h1.52
  text "." at 14.23,55.95 h1.52
  text "SCLK/M1/IN4/RSVD" at 68.752,54.102 h1.52
  text "STEP/IN3/RSVD" at 68.752,51.511 h1.52
  text "DIR/IN2" at 68.752,48.87 h1.52
  text "ENABLE/IN1" at 68.762,46.584 h1.52
  text "GND" at 89.655,44.679 h1.02
  text "nSLEEP" at 68.732,43.866 h1.52
  text "AOUT1" at 120.675,43.002 h1.52 r90
  text "OUT1" at 125.197,42.951 h1.52 r90
  text "C2000 connector" at 42.901,37.871 h2.75
  text "ID3" at 8.966,37.109 h1.52
  text "ID2" at 9.576,35.331 h1.52
  text "ID1" at 9.576,33.807 h1.52
  text "LAUNCHXL-F280025C" at 40.767,33.704 h2.75
  text "'.PRJ_Number'.PCB_Rev" at 96.284,26.949 h2.75
  text "GND" at 2.278,23.774 h1.85 r90
  text "DRV89x2" at 3.81,21.844 h1.14 r90
  text "MCU_STATUS" at 5.969,21.844 h0.76 r90
  text "GUI_STATUS" at 8.814,21.844 h0.76 r90
  text "EN1" at 12.174,21.844 h1.02 r90
  text "EN2" at 15.377,21.844 h1.02 r90
  text "EN3" at 18.517,21.844 h1.02 r90
  text "EN4" at 21.753,21.844 h1.02 r90
  text "DRV82x2" at 3.81,16.448 h1.14 r90
  text "MCU_STATUS" at 5.994,16.448 h0.76 r90
  text "GUI_STATUS" at 8.865,16.448 h0.76 r90
  text "SINGLE" at 12.141,16.448 h1.02 r90
  text "DUAL" at 15.451,16.448 h1.02 r90
  text "NA" at 18.517,16.448 h1.02 r90
  text "NA" at 21.59,16.448 h1.02 r90
  text "DRV84x2" at 3.81,10.744 h1.14 r90
  text "MCU_STATUS" at 5.994,10.49 h0.76 r90
  text "GUI_STATUS" at 8.865,10.49 h0.76 r90
  text "DRV_ENABLE" at 12.167,10.49 h0.76 r90
  text "ACCEL/DECEL" at 15.569,10.49 h0.76 r90
  text "INDEXER HOME" at 18.601,10.49 h0.76 r90
  text "NA" at 21.666,10.49 h1.02 r90
  text "GND" at 24.079,1.93 h1.85
  text "3V3" at 77.876,0.889 h1.85
  text ".Layer_Name" at 14.656,-21.806 h1.52
  text "ID1" at -10.73,-41.426 h1.52 r90
  text "ID2" at -9.133,-41.426 h1.52 r90
Bottom Overlay:
  text ".Layer_Name" at 14.656,-21.806 h1.52
Top Paste:
  text ".Layer_Name" at 14.656,-21.806 h1.52
Bottom Paste:
  text ".Layer_Name" at 14.656,-21.806 h1.52
Top Solder:
  text ".Layer_Name" at 14.656,-21.806 h1.52
  text ".Layer_Name" at 14.656,-21.806 h1.52
Bottom Solder:
  text ".Layer_Name" at 14.656,-21.806 h1.52
Drill Guide:
  text ".Layer_Name" at 14.656,-21.806 h1.52
M1 Board Outline:
  circle w0.254: c120.5,120.5 r1.8
  circle w0.254: c120.5,6.5 r1.8
  circle w0.254: c6.5,-6.5 r1.8
  circle w0.254: c6.5,120.5 r1.8
  lines w0.254: 0,0 0,127 127,127 127,0 0,0
  text ".Layer_Name" at 14.656,-21.806 h1.52
M2 Board Dimensions:
  rectangle: 0,-6.985 3.175,-3.81
  rectangle: 3.175,-10.16 12.7,-6.985
  lines w0.178: 0,-6.985 25.4,-6.985 ; 3.175,-10.16 3.175,-3.81 ; 6.35,-10.16 6.35,-3.81 ; 12.7,-10.16 12.7,-3.81 ; 19.05,-10.16 19.05,-3.81 ; 0,-10.16 25.4,-10.16 25.4,-3.81 0,-3.81 0,-10.16
  text ".Layer_Name" at 14.656,-21.806 h1.52
M3 3D STEP Top:
  text ".Layer_Name" at 14.656,-21.806 h1.52
M4 3D STEP Bottom:
  text ".Layer_Name" at 14.656,-21.806 h1.52
M5 Assembly Top:
  lines w0.254: -7.417,-23.626 160.223,-23.626 ; -7.417,-18.462 160.274,-18.462 ; -7.417,-13.297 -7.417,-28.791 94.31,-28.791 160.274,-28.791 160.274,-13.297 -7.404,-13.297 -7.404,-28.791 32.614,-28.791 ; 55.194,-28.791 55.194,-13.297 ; 87.376,-18.462 87.376,-13.297 ; 108.712,-18.462 108.712,-13.297 ; 124.511,-28.956 124.511,-23.804
  text "COMPONENTS MARKED 'DNP' SHOULD NOT BE POPULATED." at 29.299,-8.09 h1.52
  text "ASSEMBLY VARIANT:" at 29.286,-11.024 h1.52
  text ".VariantName" at 55.601,-11.024 h1.52
  text "PCB VIEWED FROM TOP SIDE" at -5.804,-16.654 h1.52
  text "BOARD #:" at 57.099,-16.654 h1.52
  text ".PRJ_Number" at 70.955,-16.654 h1.52
  text "REV:" at 92.405,-16.654 h1.52
  text ".PCB_Rev" at 99.809,-16.654 h1.52
  text "SVN REV:" at 113.69,-16.654 h1.52
  text ".VersionControl_RevNumber" at 126.543,-16.654 h1.52
  text "TID #:" at 57.099,-21.819 h1.52
  text ".TID" at 70.955,-21.819 h1.52
  text "PLOT NAME =" at -5.804,-27.034 h1.52
  text ".plot_File_Name" at 14.656,-27.034 h1.52
  text "GENERATED    :" at 57.15,-27.034 h1.52
  text ".Print_Date" at 79.235,-27.034 h1.52
  text ".Print_Time" at 97.752,-27.034 h1.52
  text "TEXAS INSTRUMENTS" at 129.87,-27.034 h1.52
M6 Assembly Bottom:
  lines w0.254: -7.429,-18.474 160.261,-18.474 ; -7.379,-23.639 160.261,-23.639 ; 28.334,-28.969 28.334,-23.817 ; 44.133,-18.474 44.133,-13.31 ; 65.468,-18.474 65.468,-13.31 ; 97.65,-28.804 97.65,-13.31 ; 120.231,-28.804 160.249,-28.804 160.249,-13.31 -7.429,-13.31 -7.429,-28.804 58.534,-28.804 160.261,-28.804 160.261,-13.31
  text "COMPONENTS MARKED 'DNP' SHOULD NOT BE POPULATED." at 154.991,-8.077 h1.52
  text ".VariantName" at 128.473,-11.024 h1.52
  text "ASSEMBLY VARIANT:" at 154.864,-11.024 h1.52
  text ".VersionControl_RevNumber" at 26.302,-16.667 h1.52
  text "SVN REV:" at 39.154,-16.667 h1.52
  text ".PCB_Rev" at 53.035,-16.667 h1.52
  text "REV:" at 60.439,-16.667 h1.52
  text ".PRJ_Number" at 81.89,-16.667 h1.52
  text "BOARD #:" at 95.745,-16.667 h1.52
  text "PCB VIEWED FROM BOTTOM SIDE" at 158.648,-16.667 h1.52
  text ".TID" at 81.89,-21.831 h1.52
  text "TID #:" at 95.745,-21.831 h1.52
  text "TEXAS INSTRUMENTS" at 22.974,-27.047 h1.52
  text ".Print_Time" at 55.093,-27.047 h1.52
  text ".Print_Date" at 73.609,-27.047 h1.52
  text "GENERATED    :" at 95.694,-27.047 h1.52
  text ".plot_File_Name" at 138.189,-27.047 h1.52
  text "PLOT NAME =" at 158.648,-27.047 h1.52
M9 Title Sheet:
  drawing of 57 lines, arcs and shapes, not listed
  text "1" at 18.792,204.127 h1.78
  text "2" at 82.182,204.127 h1.78
  text "3" at 145.411,204.127 h1.78
  text "4" at 209.08,204.127 h1.78
  text "5" at 272.555,204.127 h1.78
  text "6" at 336.182,204.127 h1.78
  text "A" at -10.579,175.095 h1.78
  text "A" at 365.341,175.095 h1.78
  text "B" at -10.579,114.643 h1.78
  text "B" at 365.341,114.643 h1.78
  text "C" at -10.579,54.318 h1.78
  text "C" at 365.341,54.318 h1.78
  text "PROJECT TITLE:" at 288.125,7.048 h1.14
  text ".PRJ_Title" at 289.395,3.662 h1.78
  text "DESIGNED FOR:" at 288.125,-0.597 h1.14
  text ".PRJ_Customer" at 289.395,-4.153 h1.78
  text "D" at -10.579,-5.88 h1.78
  text "D" at 365.341,-5.88 h1.78
  text "FILE NAME:" at 288.125,-8.217 h1.14
  text ".PCB_File_Name_No_Path" at 289.395,-11.265 h1.78
  text "Texas Instruments (TI) and/or its licensors do not warrant the accuracy or completeness of this specification" at 161.9,-15.376 h1.14
  text "ENGINEER:" at 288.125,-15.583 h1.14
  text "LAYOUT BY:" at 326.352,-15.583 h1.14
  text "or any information contained therein. TI and/or its licensors do not warrant that this design will meet" at 160.757,-18.237 h1.14
  text ".PRJ_Engineer" at 289.395,-19.52 h1.78
  text ".PCB_Layout" at 327.635,-19.52 h1.78
  text "the specifications, will be suitable for your application or fit for any particular purpose, or will operate in" at 160.757,-21.099 h1.14
  text ".Layer_Name" at 14.656,-21.806 h1.52
  text "ALTIUM DESIGNER VERSION:" at 326.352,-23.457 h1.14
  text "an implementation. TI and/or its licensors do not warrant that the design is production worthy. You should" at 160.757,-23.961 h1.14
  text "completely validate and test your design implementation to confirm the system functionality for your application." at 161.9,-26.822 h1.14
  text ".print_Scale" at 289.395,-26.843 h1.78
  text ".Application_BuildNumber" at 327.635,-26.843 h1.78
  text "1" at 18.792,-32.093 h1.78
  text "2" at 82.182,-32.093 h1.78
  text "3" at 145.411,-32.093 h1.78
  text "4" at 209.08,-32.093 h1.78
  text "5" at 272.555,-32.093 h1.78
  text "6" at 336.182,-32.093 h1.78
M10 Fab Notes:
  drawing of 189 lines, arcs and shapes, not listed
  text "DESIGN INFORMATION" at 314.503,161.447 h1.52
  text "MIN. TRACK WIDTH:" at 298.131,158.091 h1.52
  text "8" at 325.976,158.091 h1.52
  text "MIL" at 329.907,158.091 h1.52
  text "MIN. CLEARANCE:" at 298.131,154.938 h1.52
  text "0.2" at 324.452,154.938 h1.52
  text "mm" at 329.907,154.938 h1.52
  text "MIN. VIA PAD SIZE:" at 298.131,151.785 h1.52
  text "24" at 325.214,151.785 h1.52
  text "MIL" at 329.907,151.785 h1.52
  text "0.05mm (2MIL)" at 315.784,148.486 h1.52
  text "MINIMUM ANNULAR RING" at 289.769,148.277 h1.52
  text "EXTERNAL" at 333.768,148.277 h1.52
  text "PER" at 294.849,145.48 h1.52
  text "IPC-D-275 CLASS 2 LEVEL C" at 300.437,145.48 h1.52
  text "MIL, HOLES" at 338.238,142.928 h1.52
  text "+/-" at 328.27,142.709 h1.52
  text "+/-" at 349.961,142.709 h1.52
  text "REGISTRATION TOLERANCES:" at 289.769,142.682 h1.52
  text "METAL" at 320.243,142.682 h1.52
  text "5" at 334.879,142.683 h1.52
  text "3" at 356.037,142.683 h1.52
  text "MIL" at 358.99,142.682 h1.52
  text "HOLE SIZE TOLERANCE (UNLESS OTHERWISE SPECIFIED):" at 289.769,140.185 h1.52
  text "+/-" at 349.961,140.112 h1.52
  text "3" at 356.037,140.085 h1.52
  text "MIL" at 358.99,140.085 h1.52
  text "MATERIAL:" at 287.87,136.589 h1.52
  text "FR-4 High Tg" at 312.926,133.324 h1.52
  text "X" at 309.257,133.122 h1.52
  text "FR-408" at 298.563,133.007 h1.52
  text "OTHER" at 336.358,133.007 h1.52
  text "62 MIL (1.6mm) +/-10%" at 306.694,129.374 h1.52
  text "X" at 303.643,129.312 h1.52
  text "THICKNESS:" at 289.769,129.165 h1.52
  text "OTHER" at 339.33,129.165 h1.52
  text "TOLERANCE:" at 289.769,125.652 h1.52
  text "X" at 311.314,125.652 h1.52
  text "ANSI IPC-6012 TYPE 3 CLASS 2" at 315.836,125.652 h1.52
  text "OTHER +/-" at 315.835,121.989 h1.52
  text "BOW & TWIST:" at 289.769,118.302 h1.52
  text "X" at 311.314,118.302 h1.52
  text "ANSI IPC-6012 TYPE 3 CLASS 2" at 315.836,118.302 h1.52
  text "OTHER +/-" at 315.835,114.576 h1.52
  text "DRILLING:" at 287.87,111.258 h1.52
  text "NC_DRILL FILES" at 332.599,108.586 h1.52
  text "REFERENCE:" at 289.769,108.486 h1.52
  text "X" at 306.463,108.484 h1.52
  text "AS SHOWN" at 310.984,108.486 h1.52
  text "X" at 329.348,108.486 h1.52
  text "OTHER" at 340.168,104.873 h1.52
  text "PTH COPPER THICKNESS:" at 289.761,104.783 h1.52
  text "X" at 318.697,104.783 h1.52
  text "20-30 um" at 321.948,104.783 h1.52
  text "BOARD FINISH:" at 287.87,101.034 h1.52
  text "SILKSCREEN:" at 291.812,98.237 h1.52
  text "X" at 316.14,98.237 h1.52
  text "TOP" at 319.112,98.237 h1.52
  text "X" at 329.094,98.237 h1.52
  text "BOTTOM" at 332.091,98.237 h1.52
  text "SILKSCREEN COLOR:" at 291.812,94.295 h1.52
  text "X" at 316.115,94.295 h1.52
  text "WHITE" at 319.112,94.295 h1.52
  text "OTHER" at 332.091,94.295 h1.52
  text "X" at 319.442,90.652 h1.52
  text "GREEN" at 322.439,90.652 h1.52
  text "OTHER" at 338.136,90.652 h1.52
  text "SOLDER RESIST COLOR:" at 291.812,90.477 h1.52
  text "X" at 319.442,86.734 h1.52
  text "MATTE" at 322.439,86.734 h1.52
  text "SEMI-GLOSS" at 338.125,86.717 h1.52
  text "IMMERSION GOLD (ENIG)" at 314.819,82.345 h1.52
  text "ENEPIG" at 348.793,82.162 h1.52
  text "SURFACE FINISH:" at 287.87,82.136 h1.52
  text "X" at 310.298,82.136 h1.52
  text "IMM. TIN/SILVER OR EQUIV" at 296.24,78.649 h1.52
  text "OTHER" at 332.599,78.549 h1.52
  text "ARRAY/PANEL:" at 287.87,74.602 h1.52
  text "CUT AND TRIM PER M1 BOARD OUTLINE" at 314.819,74.393 h1.52
  text "N.C. ROUTE" at 314.819,70.94 h1.52
  text "X" at 332.295,70.94 h1.52
  text "V. SCORE" at 336.816,70.94 h1.52
  text "CERTIFICATION:" at 287.87,67.66 h1.52
  text "MATERIALS AND WORKMANSHIP FOR ALL PCBS" at 306.285,67.66 h1.52
  text "TO MEET OR EXCEED THE REQUIREMENTS OF:" at 306.285,65.271 h1.52
  text "X" at 297.078,62.003 h1.52
  text "ANSI IPC-A-600F CLASS ->" at 300.329,62.003 h1.52
  text "X" at 342.188,62.003 h1.52
  text "2" at 344.982,62.003 h1.52
  text "1" at 336.981,61.965 h1.52
  text "3" at 353.973,61.965 h1.52
  text "X" at 317.702,58.252 h1.52
  text "RoHS" at 320.953,58.252 h1.52
  text "OTHER" at 337.321,58.252 h1.52
  text "PER ORDER" at 347.407,58.252 h1.52
  text "ALL BOARDS MUST MEET OR EXCEED UL94-V0 REQUIREMENTS." at 288.569,54.345 h1.52
  text "PCB MUST BEAR THE UL94V-0 UL REGISTERED MATERIAL ID NUMBER" at 288.569,51.397 h1.52
  text "ADDITIONAL REQUIREMENTS:" at 287.87,47.094 h1.52
  text "MICROSECTION:" at 289.769,44.373 h1.52
  text "YES" at 312.775,44.373 h1.52
  text "REQUIRED" at 334.657,40.707 h1.52
  text "BARE BOARD ELEC. TEST:" at 289.769,40.634 h1.52
  text "NONE" at 322.935,40.634 h1.52
  text "X" at 331.66,40.634 h1.52
  text "PER ORDER" at 349.693,40.634 h1.52
  text "XX MIL VIAS REQUIRE NON-CONDUCTIVE FILL AND PLANARIZE" at 294.04,35.428 h1.5
  text "XX MIL VIAS REQUIRE CONDUCTIVE FILL AND PLANARIZE" at 294.243,32.787 h1.52
  text "OUTER XX MIL TRACES REQUIRE 50 OHM SINGLE-ENDED IMPEDANCE" at 294.218,28.637 h1.47
  text "LAYER 2 & 3 (INNER LAYERS) XX MIL WIDE, XX MIL SPACE / TRACES REQUIRE 100 OHM DIFFERENTIAL IMPEDANCE" at 294.015,22.65 h1.52
  text ".Layer_Name" at 14.656,-21.806 h1.52
M11 Gerber Information:
  lines w0.254: -7.417,-23.626 160.223,-23.626 ; -7.417,-18.462 160.274,-18.462 ; -7.417,-13.297 -7.417,-28.791 94.31,-28.791 160.274,-28.791 160.274,-13.297 -7.404,-13.297 -7.404,-28.791 32.614,-28.791 ; 55.194,-28.791 55.194,-13.297 ; 87.376,-18.462 87.376,-13.297 ; 108.712,-18.462 108.712,-13.297 ; 124.511,-28.956 124.511,-23.804
  text "ALL ARTWORK VIEWED FROM TOP SIDE" at -5.804,-16.654 h1.52
  text "BOARD #:" at 57.099,-16.654 h1.52
  text ".PRJ_Number" at 70.955,-16.654 h1.52
  text "REV:" at 92.405,-16.654 h1.52
  text ".PCB_Rev" at 99.809,-16.654 h1.52
  text "SVN REV:" at 113.69,-16.654 h1.52
  text ".VersionControl_RevNumber" at 126.543,-16.654 h1.52
  text "LAYER NAME =" at -5.804,-21.806 h1.52
  text "TID #:" at 57.099,-21.819 h1.52
  text ".TID" at 70.955,-21.819 h1.52
  text "PLOT NAME =" at -5.804,-27.034 h1.52
  text ".plot_File_Name" at 14.656,-27.034 h1.52
  text "GENERATED    :" at 57.15,-27.034 h1.52
  text ".Print_Date" at 79.235,-27.034 h1.52
  text ".Print_Time" at 97.752,-27.034 h1.52
  text "TEXAS INSTRUMENTS" at 129.87,-27.034 h1.52
M12 Stackup:
  drawing of 295 lines, arcs and shapes, not listed
  text "Layer" at 248.319,199.492 h1.52
  text "Name" at 258.731,199.492 h1.52
  text "Material" at 282.6,199.492 h1.52
  text "Thickness" at 304.438,199.492 h1.52
  text "Constant" at 320.944,199.492 h1.52
  text "Board Layer Stack" at 335.419,199.492 h1.52
  text "Top Overlay" at 258.731,196.444 h1.52
  text "Top Solder" at 258.731,193.396 h1.52
  text "Solder Resist" at 282.6,193.396 h1.52
  text "0.40mil" at 304.438,193.396 h1.52
  text "3.5" at 320.944,193.396 h1.52
  text "1" at 248.319,190.348 h1.52
  text "Top Layer" at 258.731,190.348 h1.52
  text "2.80mil" at 304.438,190.348 h1.52
  text "Dielectric 1" at 258.731,187.3 h1.52
  text "FR4 370" at 282.6,187.3 h1.52
  text "11.40mil" at 304.438,187.3 h1.52
  text "4.2" at 320.944,187.3 h1.52
  text "2" at 248.319,184.252 h1.52
  text "Signal Layer 1" at 258.731,184.252 h1.52
  text "1.40mil" at 304.438,184.252 h1.52
  text "Dielectric 2" at 258.731,181.204 h1.52
  text "FR4 370" at 282.6,181.204 h1.52
  text "30.00mil" at 304.438,181.204 h1.52
  text "4.2" at 320.944,181.204 h1.52
  text "3" at 248.319,178.156 h1.52
  text "Signal Layer 2" at 258.731,178.156 h1.52
  text "1.40mil" at 304.438,178.156 h1.52
  text "Dielectric 3" at 258.731,175.108 h1.52
  text "FR4 370" at 282.6,175.108 h1.52
  text "11.40mil" at 304.438,175.108 h1.52
  text "4.2" at 320.944,175.108 h1.52
  text "4" at 248.319,172.06 h1.52
  text "Bottom Layer" at 258.731,172.06 h1.52
  text "2.80mil" at 304.438,172.06 h1.52
  text "Bottom Solder" at 258.731,169.012 h1.52
  text "Solder Resist" at 282.6,169.012 h1.52
  text "0.40mil" at 304.438,169.012 h1.52
  text "3.5" at 320.944,169.012 h1.52
  text "Bottom Overlay" at 258.731,165.964 h1.52
  text ".Layer_Name" at 14.656,-21.806 h1.52
M13 Component Bodies Top:
  text ".Layer_Name" at 14.656,-21.806 h1.52
M14 Component Bodies Bottom:
  text ".Layer_Name" at 14.656,-21.806 h1.52
M15 Courtyards Top:
  text ".Layer_Name" at 14.656,-21.806 h1.52
M16 Courtyards Bottom:
  text ".Layer_Name" at 14.656,-21.806 h1.52
Drill Drawing:
  circle w0.254: c3.037,197.506 r0.421
  circle w0.254: c3.037,197.506 r0.702
  circle w0.254: c3.037,178.56 r0.702
  lines w0.254: 2.335,162.07 2.335,162.42 2.686,162.771 2.335,163.122 2.335,163.473 2.686,163.473 3.037,163.122 3.388,163.473 3.739,163.473 3.739,163.122 3.388,162.771 3.739,162.42 3.739,162.07 3.388,162.07 3.037,162.42 2.686,162.07 2.335,162.07 ; 2.335,165.578 2.686,165.578 3.037,165.227 3.388,165.578 3.739,165.578 3.388,165.929 3.739,166.28 3.388,166.28 3.037,166.631 2.686,166.28 2.335,166.28 2.686,165.929 2.335,165.578 ; 2.335,168.736 2.686,168.736 3.037,168.385 3.388,168.736 3.739,168.736 3.388,169.087 3.739,169.438 3.388,169.438 3.037,169.788 2.686,169.438 2.335,169.438 2.686,169.087 2.335,168.736 ; 2.335,171.543 3.037,171.894 3.739,171.543 3.388,172.244 3.739,172.946 3.037,172.595 2.335,172.946 2.686,172.244 2.335,171.543 ; 2.335,174.7 3.037,175.051 3.739,174.7 3.388,175.402 3.739,176.104 3.037,175.753 2.335,176.104 2.686,175.402 2.335,174.7 ; 2.335,182.419 3.739,182.419 3.037,181.016 2.335,182.419 ; 2.335,185.577 3.739,185.577 3.037,184.174 2.335,185.577 ; 2.335,188.033 3.037,187.331 3.739,188.033 3.037,188.735 2.335,188.033 ; 2.335,190.489 3.739,190.489 3.739,191.893 2.335,191.893 2.335,190.489 ; 2.335,193.647 3.739,193.647 3.739,195.05 2.335,195.05 2.335,193.647 ; 2.616,165.718 2.827,165.718 3.037,165.508 3.248,165.718 3.458,165.718 3.248,165.929 3.458,166.14 3.248,166.14 3.037,166.35 2.827,166.14 2.616,166.14 2.827,165.929 2.616,165.718 ; 2.616,174.981 3.037,175.192 3.458,174.981 3.248,175.402 3.458,175.823 3.037,175.613 2.616,175.823 2.827,175.402 2.616,174.981 ; 2.616,182.139 3.458,182.139 3.037,181.297 2.616,182.139 ; 2.616,190.77 3.458,190.77 3.458,191.612 2.616,191.612 2.616,190.77
  lines w0.305: 1.063,161.122 83.143,161.122 ; 1.063,199.015 83.143,199.015 ; 9.645,157.965 9.645,202.173 ; 18.078,157.965 18.078,202.173 ; 34.246,157.965 34.246,202.173 ; 40.829,157.965 40.829,202.173 ; 50.358,157.965 50.358,202.173 ; 68.756,157.965 68.756,202.173 ; 1.063,157.965 83.143,157.965 83.143,202.173 1.063,202.173 1.063,157.965
  text "Symbol" at 2.958,199.962 h1.83
  text "Quantity" at 10.592,199.962 h1.83
  text "Finished Hole Size" at 19.025,199.962 h1.83
  text "Plated" at 35.194,199.962 h1.83
  text "Hole Type" at 41.776,199.962 h1.83
  text "Drill Layer Pair" at 51.305,199.962 h1.83
  text "Hole Tolerance" at 69.703,199.962 h1.83
  text "87" at 10.592,196.805 h1.52
  text "7.87mil (0.200mm)" at 19.025,196.805 h1.52
  text "PTH" at 35.194,196.805 h1.52
  text "Round" at 41.776,196.805 h1.52
  text "Top Layer - Bottom Layer" at 51.305,196.805 h1.52
  text "211" at 10.592,193.647 h1.52
  text "13.78mil (0.350mm)" at 19.025,193.647 h1.52
  text "PTH" at 35.194,193.647 h1.52
  text "Round" at 41.776,193.647 h1.52
  text "Top Layer - Bottom Layer" at 51.305,193.647 h1.52
  text "20" at 10.592,190.489 h1.52
  text "17.72mil (0.450mm)" at 19.025,190.489 h1.52
  text "PTH" at 35.194,190.489 h1.52
  text "Round" at 41.776,190.489 h1.52
  text "Top Layer - Bottom Layer" at 51.305,190.489 h1.52
  text "48" at 10.592,187.331 h1.52
  text "40.00mil (1.016mm)" at 19.025,187.331 h1.52
  text "PTH" at 35.194,187.331 h1.52
  text "Round" at 41.776,187.331 h1.52
  text "Top Layer - Bottom Layer" at 51.305,187.331 h1.52
  text "43" at 10.592,184.174 h1.52
  text "40.16mil (1.020mm)" at 19.025,184.174 h1.52
  text "PTH" at 35.194,184.174 h1.52
  text "Round" at 41.776,184.174 h1.52
  text "Top Layer - Bottom Layer" at 51.305,184.174 h1.52
  text "14" at 10.592,181.016 h1.52
  text "43.31mil (1.100mm)" at 19.025,181.016 h1.52
  text "PTH" at 35.194,181.016 h1.52
  text "Round" at 41.776,181.016 h1.52
  text "Top Layer - Bottom Layer" at 51.305,181.016 h1.52
  text "+/-1.97mil" at 69.703,181.016 h1.52
  text "8" at 10.592,177.858 h1.52
  text "51.18mil (1.300mm)" at 19.025,177.858 h1.52
  text "PTH" at 35.194,177.858 h1.52
  text "Round" at 41.776,177.858 h1.52
  text "Top Layer - Bottom Layer" at 51.305,177.858 h1.52
  text "6" at 10.592,174.7 h1.52
  text "59.06mil (1.500mm)" at 19.025,174.7 h1.52
  text "PTH" at 35.194,174.7 h1.52
  text "Round" at 41.776,174.7 h1.52
  text "Top Layer - Bottom Layer" at 51.305,174.7 h1.52
  text "4" at 10.592,171.543 h1.52
  text "62.99mil (1.600mm)" at 19.025,171.543 h1.52
  text "PTH" at 35.194,171.543 h1.52
  text "Round" at 41.776,171.543 h1.52
  text "Top Layer - Bottom Layer" at 51.305,171.543 h1.52
  text "24" at 10.592,168.385 h1.52
  text "63.00mil (1.600mm)" at 19.025,168.385 h1.52
  text "PTH" at 35.194,168.385 h1.52
  text "Round" at 41.776,168.385 h1.52
  text "Top Layer - Bottom Layer" at 51.305,168.385 h1.52
  text "5" at 10.592,165.227 h1.52
  text "141.73mil (3.600mm)" at 19.025,165.227 h1.52
  text "PTH" at 35.194,165.227 h1.52
  text "Round" at 41.776,165.227 h1.52
  text "Top Layer - Bottom Layer" at 51.305,165.227 h1.52
  text "2" at 10.592,162.07 h1.52
  text "23.62mil (0.600mm)" at 19.025,162.07 h1.52
  text "PTH" at 35.194,162.07 h1.52
  text "Slot" at 41.776,162.07 h1.52
  text "Top Layer - Bottom Layer" at 51.305,162.07 h1.52
  text "472 Total" at 10.592,158.912 h1.52
  text "Slot definitions :" at 2.958,156.701 h1.52
  text "Routed Path Length" at 14.406,156.701 h1.52
  text "= Calculated from tool start centre position to tool end centre position." at 28.115,156.701 h1.52
  text "Hole Length" at 14.406,155.438 h1.52
  text "= Routed Path Length + Tool Size = Slot length as defined in the PCB layout" at 23.04,155.438 h1.52
  text ".Layer_Name" at 14.656,-21.806 h1.52
Mechanical 17:
  text ".Layer_Name" at 14.656,-21.806 h1.52
Mechanical 18:
  text ".Layer_Name" at 14.656,-21.806 h1.52
Mechanical 19:
  text ".Layer_Name" at 14.656,-21.806 h1.52

## Dimensions
0,-2.4 to 101.6,-0.9 on M1 Board Outline
0,-10.16 to 25.4,-10.16 on M2 Board Dimensions
0,0 to 0,127 on M2 Board Dimensions