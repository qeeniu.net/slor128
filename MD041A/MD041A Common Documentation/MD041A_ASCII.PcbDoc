# Altium PCB MD041A_ASCII.PcbDoc (part 4 of 6)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 6709.84 x 5059.84 mil, 4 copper layers (Top Layer, Signal Layer 1, Signal Layer 2, Bottom Layer), stack 61.2 mil thick; 351 components, 206 nets, 927 pads, 324 vias.

## Components (designator, comment, footprint, x,y, rotation, side; value= is the part's Value field where it differs from the comment) (continued)
TP24 "TP_H0.45P0.75" TP_H045P075 1356.71,1236 r0 top
TP25 "5011" Keystone5011 240,1515 r270 top
TP26 "TP_H0.45P0.75" TP_H045P075 1388.47,1301.29 r0 top
TP27 "5010" Keystone5010 1188.31,3165 r0 top
TP28 "5010" Keystone5010 3665.42,2545 r0 top
TP29 "5011" Keystone5011 4875.98,4897.53 r0 top
TP30 "5010" Keystone5010 3551.18,3818.25 r180 top
TP31 "5015" Testpoint_Keystone_Miniature 6532.84,3228.91 r90 top
TP32 "5015" Testpoint_Keystone_Miniature 6534.91,2431.3 r270 top
TP34 "5015" Testpoint_Keystone_Miniature 6538.91,1408.91 r270 top
TP35 "5015" Testpoint_Keystone_Miniature 6532.91,2200.91 r270 top
TP36 "5010" Keystone5010 3406.98,4897.53 r0 top
TP37 "5012" Keystone5012 3534.79,366 r0 top
TP38 "5012" Keystone5012 3346.46,403.54 r0 top
TP39 "5012" Keystone5012 3534.79,546.5 r0 top
TP40 "5012" Keystone5012 3343.95,587 r0 top
TP41 "5012" Keystone5012 3531.16,726 r0 top
TP42 "5012" Keystone5012 3345.04,788 r0 top
TP43 "5012" Keystone5012 3532.25,904 r0 top
TP44 "5012" Keystone5012 3350.39,985.24 r0 top
TP45 "5012" Keystone5012 3533.35,1082 r0 top
TP46 "5012" Keystone5012 713.35,243 r0 top
U1 "MSP430F5338IPZ" PZT0100A_N 950,1780 r270 top locked
U2 "MSP430F5528IRGCT" RGC0064B 944.28,4025.21 r315 top
U3 "TPS73533DRBR" DRB0008A 1405.05,4364.77 r90 top
U4 "FT232RL" SSOP28_N 1989.62,4424 r0 top
U5 "TPS7A4333DGQ" DGQ0010E-MFG 1795,3965 r0 top
U6 "TPD2E001DRYR" DRY0006A 1501.07,4695.58 r90 top
U7 "DRV8962DDVR" DDV0044E-MFG 4585,2050 r180 top
Y1 "CSTNR4M00GH5L000R0" MuRata_CSTNR 1119.82,4375.65 r135 top
Y2 "MS3V-T1R 32.768KHZ +/-20PPM 12.5PF" XTAL_MS3V-T1R 1025,2880 r90 top
ZZ1 "This Assembly Note is for PCB labels only" AssemblyNoteLabel 206.65,5594.5 r0 top
ZZ2 "These assemblies are ESD sensitive, ESD precautions shall be observed." AssemblyNote 206.65,5485.61 r0 top
ZZ3 "These assemblies must be clean and free from flux and all contaminants. Use of no clean flux is not acceptable." AssemblyNote 206.65,5397.05 r0 top
ZZ4 "These assemblies must comply with workmanship standards IPC-A-610 Class 2, unless otherwise specified." AssemblyNote 206.65,5308.5 r0 top

## Footprints (in the part's own frame and the unit in brackets; to place one, negate y for a bottom-side part, rotate by r counter-clockwise, add the part's x,y. Pads: shape width x height; smd on the part's side, far side on the other; paste and mask are expansions set on the pad)
0402 [mm] "0402 from SM-752 data"
  rect 0.8x0.6 smd: 1(-0.6,0) 2(0.6,0)
  silkscreen extent -1.22,-0.52 1.22,0.52
0402L [mm] "0402 from SM-752 data"
  rect 0.6x0.5 smd: 1(-0.5,0) 2(0.5,0)
0603 [mm] "0603 from SM-752 data"
  rect 1x0.95 smd: 1(-0.8,0) 2(0.8,0)
  silkscreen extent -1.52,-0.69 1.52,0.69
0603L [mm] "0603 from SM-752 data"
  rect 0.8x0.85 smd: 1(-0.7,0) 2(0.7,0)
  silkscreen extent -0.07,-0.33 0.07,0.33
0805_HV [mil] "0805 with 30mil clearance between pads"
  rect 50x63 smd: 1(-40,0) 2(40,0)
  silkscreen extent -74,-40 74,40
1210_220 [mm] "1210"
  rect 1.3x2.7 smd: 1(-1.45,0) 2(1.45,0)
  silkscreen extent -2.32,-1.57 2.32,1.57
3216-18 [mm] "Based on AVX recommendation in http://www.avx.com/download/software/literature/AVX-Footprint-Library.pdf"
  rrect7% 1.4x1.8 smd: 1(-1.3,0) 2(1.3,0)
  silkscreen extent -1.9,-1.12 0.8,1.12
AssemblyNote [mil] "Assembly Note"
AssemblyNoteLabel [mil] "Assembly Note for PCB Labels"
CE_Mark_5mm [mil] "Minimum text height for CE Mark"
DDV0044E-MFG [mm]
  rrect25% 1.45x0.4 smd paste+0 mask+0: 1(-3.75,6.667) 2(-3.75,6.032) 3(-3.75,5.397) 4(-3.75,4.762) 5(-3.75,4.127) 6(-3.75,3.492) 7(-3.75,2.857) 8(-3.75,2.222) 9(-3.75,1.587) 10(-3.75,0.952) 11(-3.75,0.317) 12(-3.75,-0.318) 13(-3.75,-0.953) 14(-3.75,-1.588) 15(-3.75,-2.223) 16(-3.75,-2.858) 17(-3.75,-3.493) 18(-3.75,-4.128) 19(-3.75,-4.763) 20(-3.75,-5.398) 21(-3.75,-6.033) 22(-3.75,-6.667) 23(3.75,-6.667) 24(3.75,-6.032) 25(3.75,-5.397) 26(3.75,-4.762) 27(3.75,-4.127) 28(3.75,-3.492) 29(3.75,-2.857) 30(3.75,-2.222) 31(3.75,-1.587) 32(3.75,-0.952) 33(3.75,-0.317) 34(3.75,0.318) 35(3.75,0.953) 36(3.75,1.588) 37(3.75,2.223) 38(3.75,2.858) 39(3.75,3.493) 40(3.75,4.128) 41(3.75,4.763) 42(3.75,5.398) 43(3.75,6.033) 44(3.75,6.667)
  silkscreen extent -5.15,-7.05 2.65,7.05
DGQ0010E-MFG [mm]
  rrect33% 1.45x0.3 smd paste+0 mask+0: 1(-2.2,1) 2(-2.2,0.5) 3(-2.2,0) 4(-2.2,-0.5) 5(-2.2,-1) 6(2.2,-1) 7(2.2,-0.5) 8(2.2,0) 9(2.2,0.5) 10(2.2,1)
  rrect5% 2.2x3.1 smd paste-1000 mask+0: 11(0,0)
  silkscreen extent -3.6,-1.65 1.65,1.65
DRB0008A [mm] "VSON-8"
  rrect32% 0.6x0.31 smd: 1(-1.4,0.975) 2(-1.4,0.325) 3(-1.4,-0.325) 4(-1.4,-0.975) 5(1.4,-0.975) 6(1.4,-0.325) 7(1.4,0.325) 8(1.4,0.975)
  rrect7% 1.5x1.75 smd paste-0.75: 9(0,0)
  silkscreen extent -1.73,-1.73 1.73,1.73
DRY0006A [mm] "USON-6"
  rrect67% 0.45x0.3 smd paste-0.05 mask+0: 1(-0.275,0.5)
  rrect67% 0.4x0.3 smd paste-0.05 mask+0: 2(-0.3,0) 3(-0.3,-0.5) 4(0.3,-0.5) 5(0.3,0) 6(0.3,0.5)
FCC_disclaimer [mil]
Fiducial10-20 [mm]
  round 1 smd mask+0: 1(0,0)
  Top Layer keep-out circle w1.178: c0,0 r0.5
FP-0603-L_1_6_0_1-W_0_8_0-IPC_B [mil]
  rect 41.64x35.91 smd paste+0 mask+0: 1(-26.66,0) 2(26.66,0)
  silkscreen extent -47,-34 47,34
FP-430481025816_SMT_SW_6MM2_6MM2-MFG [mm]
  rrect7% 2x1.4 smd paste+0 mask+0: 1(-3.5,2) 2(3.5,2) 3(-3.5,-2) 4(3.5,-2)
  silkscreen extent -5.17,-3.2 3.2,3.2
FP-691250610002_CONN_TERM_BLOCK2-MFG [mm]
  rrect4% 2.3x2.3 hole 1.5 paste-1000 mask+0: 1(-2.875,1.65)
  round 2.3 hole 1.5 paste-1000 mask+0: 2(3.475,1.65)
  silkscreen extent -7.52,-6.3 6.85,6.3
FP-691256610002_HDR2-MFG [mm]
  rrect4% 2.45x2.45 hole 1.6 paste-1000 mask+0: 1(-5.08,7.55)
  round 2.45 hole 1.6 paste-1000 mask+0: 1(-5.08,-2.61) 2(5.08,7.55) 2(5.08,-2.61)
  silkscreen extent -11,-9.2 10.21,9.2
FP-885012005058_0402-MFG [mm]
  rrect20% 0.5x0.5 smd paste+0 mask+0: 1(-0.5,0) 2(0.5,0)
  silkscreen extent -0.53,-0.63 0.53,0.63
FP-885012005080_0402-MFG [mm]
  rrect20% 0.5x0.5 smd paste+0 mask+0: 1(-0.5,0) 2(0.5,0)
  silkscreen extent -0.53,-0.63 0.53,0.63
FP-885012006085_0603-MFG [mm]
  rrect13% 0.8x0.8 smd paste+0 mask+0: 1(-0.75,0) 2(0.75,0)
  silkscreen extent -0.85,-0.77 0.85,0.77
FP-885012106008_0603-MFG [mm]
  rrect13% 0.8x0.8 smd paste+0 mask+0: 1(-0.75,0) 2(0.75,0)
  silkscreen extent -0.85,-0.77 0.85,0.77
FP-885012206120_0603-MFG [mm]
  rrect13% 0.8x0.8 smd paste+0 mask+0: 1(-0.75,0) 2(0.75,0)
  silkscreen extent -0.85,-0.77 0.85,0.77
FP-ATS-TI10P-519-C1-R3_HEAT_SINK-MFG [mm]
  rect 0x0 / inner round 0 / far side round 0 hole 3 unplated paste-1000 mask+0: ""(-18.4,0) ""(18.4,0)
  silkscreen extent -39,-18 39,18
FP-BZX84J-B4V7,115_SC90-MFG [mm]
  rrect17% 0.6x0.6 smd paste-1000 mask+0: 1(-1.1,0) 2(1.1,0)
  silkscreen extent -2.08,-0.67 0.43,0.67
FP-CH0402-10RJFPT_0402-MFG [mm]
  rrect20% 0.5x0.65 smd paste+0 mask+0: 1(-0.45,0) 2(0.45,0)
  silkscreen extent -0.8,-0.7 0.8,0.7
FP-EMVY101ARA101MKE0S_RADIAL-MFG [mm]
  rrect4% 5.7x2.5 smd paste+0 mask+0: 1(-4.85,0) 2(4.85,0)
  silkscreen extent -8.37,-6.6 6.6,6.6
Fuse_0463 [mm] "SMD, 2-Leads, Body 10.1x3.12mm"
  rrect3% 3.25x3.43 smd: 1(-4.675,0) 2(4.675,0)
  silkscreen extent -2.6,-1.5 2.6,1.5
Harwin_D3082-05 [mm] "Shorting Plug, 10.16mm spacing, TH"
  round 1.8 hole 1.3: 1(-5.08,0) 2(5.08,0)
  silkscreen extent -3.9,-0.53 3.9,0.53
IEC_Caution_Small [mil]
  silkscreen extent -107,-93 107,92
IEC_HotSurface_Small [mil]
  silkscreen extent -107,-93 107,92
Keystone5010 [mil] "Keystone Multipurpose loops"
  round 87 hole 63: 1(0,0)
  silkscreen extent -70,-70 70,70
Keystone5011 [mil] "Keystone Multipurpose loops"
  round 87 hole 63: 1(0,0)
  silkscreen extent -70,-70 70,70
Keystone5012 [mil] "Keystone Multipurpose loops"
  round 87 hole 63: 1(0,0)
  silkscreen extent -70,-70 70,70
KEYSTONE_4822#1 [mil] "HEX NYLON STANDOFF 6-32, M-F"
  round 1 on Mech3: 0(0,0)
KEYSTONE_4822#2 [mil] "HEX NYLON STANDOFF 6-32, M-F"
  round 1 on Mech26: 0(0,0)
Keystone_9605 [mil] "Hex Nut,4-40 Thread, 250\" Head Dia"
Label_650x200 [mil] "Thermal Transfer Label"
  round 1 on Mech13: 0(0,0)
  silkscreen extent -325,-100 325,100
Molex_1051640001 [mm] "Receptacle, USB 2.0, Micro B, 5 Pos, 0.65mm Pitch, R/A, SMT"
  rrect22% 0.45x1.38 smd: 1(1.3,4.11) 2(0.65,4.11) 3(0,4.11) 4(-0.65,4.11) 5(-1.3,4.11)
  rrect7% 1.475x2.1 smd: 6(-2.462,3.75) 11(2.462,3.75)
  rrect100% 1.4x2.1 hole 0.6 slot 1.3 at 90 deg: 7(-3.95,1.45) 10(3.95,1.45)
  rrect7% 1.375x1.9 smd: 8(-0.938,1.45) 9(0.938,1.45)
  silkscreen extent 1.2,5.1 1.4,5.4
MuRata_CSTNR [mm] "SMD, 3-Leads, Body 4.5x2mm, Pitch 1.5mm"
  rrect25% 0.4x2.6 smd: 1(-1.5,0) 2(0,0) 3(1.5,0)
ONSC-SOD-323-2-477-02_V [mm] "SOD, 2-Leads, Body 1.7x1.25mm"
  rect 0.63x0.83 smd: 1(-1.115,0) 2(1.115,0)
  silkscreen extent -1.24,-0.67 0.4,1.09
ONSC-SOT-23-3-318-08_V [mm] "SOT23, 3-Leads, Body 2.92x1.3mm, Pitch 0.95mm"
  rect 0.9x0.8 smd: 1(-1,0.95) 2(-1,-0.95) 3(1,0)
  silkscreen extent -1.12,-1.46 0.65,2.02
PZT0100A_N [mm] "QFP, 100-Leads, Body 14x14mm, Pitch 0.50mm, IPC Medium Density"
  oval 1.45x0.3 smd: 1(-7.725,6) 2(-7.725,5.5) 3(-7.725,5) 4(-7.725,4.5) 5(-7.725,4) 6(-7.725,3.5) 7(-7.725,3) 8(-7.725,2.5) 9(-7.725,2) 10(-7.725,1.5) 11(-7.725,1) 12(-7.725,0.5) 13(-7.725,0) 14(-7.725,-0.5) 15(-7.725,-1) 16(-7.725,-1.5) 17(-7.725,-2) 18(-7.725,-2.5) 19(-7.725,-3) 20(-7.725,-3.5) 21(-7.725,-4) 22(-7.725,-4.5) 23(-7.725,-5) 24(-7.725,-5.5) 25(-7.725,-6) 51(7.725,-6) 52(7.725,-5.5) 53(7.725,-5) 54(7.725,-4.5) 55(7.725,-4) 56(7.725,-3.5) 57(7.725,-3) 58(7.725,-2.5) 59(7.725,-2) 60(7.725,-1.5) 61(7.725,-1) 62(7.725,-0.5) 63(7.725,0) 64(7.725,0.5) 65(7.725,1) 66(7.725,1.5) 67(7.725,2) 68(7.725,2.5) 69(7.725,3) 70(7.725,3.5) 71(7.725,4) 72(7.725,4.5) 73(7.725,5) 74(7.725,5.5) 75(7.725,6)
  oval 0.3x1.45 smd: 26(-6,-7.725) 27(-5.5,-7.725) 28(-5,-7.725) 29(-4.5,-7.725) 30(-4,-7.725) 31(-3.5,-7.725) 32(-3,-7.725) 33(-2.5,-7.725) 34(-2,-7.725) 35(-1.5,-7.725) 36(-1,-7.725) 37(-0.5,-7.725) 38(0,-7.725) 39(0.5,-7.725) 40(1,-7.725) 41(1.5,-7.725) 42(2,-7.725) 43(2.5,-7.725) 44(3,-7.725) 45(3.5,-7.725) 46(4,-7.725) 47(4.5,-7.725) 48(5,-7.725) 49(5.5,-7.725) 50(6,-7.725) 76(6,7.725) 77(5.5,7.725) 78(5,7.725) 79(4.5,7.725) 80(4,7.725) 81(3.5,7.725) 82(3,7.725) 83(2.5,7.725) 84(2,7.725) 85(1.5,7.725) 86(1,7.725) 87(0.5,7.725) 88(0,7.725) 89(-0.5,7.725) 90(-1,7.725) 91(-1.5,7.725) 92(-2,7.725) 93(-2.5,7.725) 94(-3,7.725) 95(-3.5,7.725) 96(-4,7.725) 97(-4.5,7.725) 98(-5,7.725) 99(-5.5,7.725) 100(-6,7.725)
  silkscreen extent -8.1,-8.2 8.1,8.2
RESC1005X40X25NL05T05 [mm] "Chip Resistor, 2-Leads, Body 1.00x0.50mm, IPC Medium Density"
  rect 0.55x0.55 smd: 1(-0.45,0) 2(0.45,0)
RGC0064B [mm] "VQFN-64"
  rrect42% 0.6x0.24 smd mask+0: 1(-4.4,3.75) 2(-4.4,3.25) 3(-4.4,2.75) 4(-4.4,2.25) 5(-4.4,1.75) 6(-4.4,1.25) 7(-4.4,0.75) 8(-4.4,0.25) 9(-4.4,-0.25) 10(-4.4,-0.75) 11(-4.4,-1.25) 12(-4.4,-1.75) 13(-4.4,-2.25) 14(-4.4,-2.75) 15(-4.4,-3.25) 16(-4.4,-3.75) 33(4.4,-3.75) 34(4.4,-3.25) 35(4.4,-2.75) 36(4.4,-2.25) 37(4.4,-1.75) 38(4.4,-1.25) 39(4.4,-0.75) 40(4.4,-0.25) 41(4.4,0.25) 42(4.4,0.75) 43(4.4,1.25) 44(4.4,1.75) 45(4.4,2.25) 46(4.4,2.75) 47(4.4,3.25) 48(4.4,3.75)
  rrect42% 0.24x0.6 smd mask+0: 17(-3.75,-4.4) 18(-3.25,-4.4) 19(-2.75,-4.4) 20(-2.25,-4.4) 21(-1.75,-4.4) 22(-1.25,-4.4) 23(-0.75,-4.4) 24(-0.25,-4.4) 25(0.25,-4.4) 26(0.75,-4.4) 27(1.25,-4.4) 28(1.75,-4.4) 29(2.25,-4.4) 30(2.75,-4.4) 31(3.25,-4.4) 32(3.75,-4.4) 49(3.75,4.4) 50(3.25,4.4) 51(2.75,4.4) 52(2.25,4.4) 53(1.75,4.4) 54(1.25,4.4) 55(0.75,4.4) 56(0.25,4.4) 57(-0.25,4.4) 58(-0.75,4.4) 59(-1.25,4.4) 60(-1.75,4.4) 61(-2.25,4.4) 62(-2.75,4.4) 63(-3.25,4.4) 64(-3.75,4.4)
  rrect2% 4.25x4.25 smd paste-2.112: 65(0,0)
Samtec_SSQ-110-03-x-D [mm] "Receptacle, 2.54mm, 10x2, TH"
  rect 1.55x1.55 hole 1.02: 1(-11.43,1.27)
  round 1.55 hole 1.02: 2(-11.43,-1.27) 3(-8.89,1.27) 4(-8.89,-1.27) 5(-6.35,1.27) 6(-6.35,-1.27) 7(-3.81,1.27) 8(-3.81,-1.27) 9(-1.27,1.27) 10(-1.27,-1.27) 11(1.27,1.27) 12(1.27,-1.27) 13(3.81,1.27) 14(3.81,-1.27) 15(6.35,1.27) 16(6.35,-1.27) 17(8.89,1.27) 18(8.89,-1.27) 19(11.43,1.27) 20(11.43,-1.27)
  silkscreen extent -12.95,-2.48 12.95,3
Samtec_TSM-108-01-x-DV [mm] "Header, 2.54mm, 8x2, SMT"
  rect 3.68x1.27 smd: 1(-2.475,8.89) 2(2.475,8.89) 3(-2.475,6.35) 4(2.475,6.35) 5(-2.475,3.81) 6(2.475,3.81) 7(-2.475,1.27) 8(2.475,1.27) 9(-2.475,-1.27) 10(2.475,-1.27) 11(-2.475,-3.81) 12(2.475,-3.81) 13(-2.475,-6.35) 14(2.475,-6.35) 15(-2.475,-8.89) 16(2.475,-8.89)
  silkscreen extent -1.65,-10.16 1.65,10.3
SSOP28_N [mm] "SOP, 28-Leads, Body 10.2x5.3mm, Pitch 0.65mm, IPC Medium Density"
  oval 2.1x0.45 smd: 1(-3.45,4.225) 2(-3.45,3.575) 3(-3.45,2.925) 4(-3.45,2.275) 5(-3.45,1.625) 6(-3.45,0.975) 7(-3.45,0.325) 8(-3.45,-0.325) 9(-3.45,-0.975) 10(-3.45,-1.625) 11(-3.45,-2.275) 12(-3.45,-2.925) 13(-3.45,-3.575) 14(-3.45,-4.225) 15(3.45,-4.225) 16(3.45,-3.575) 17(3.45,-2.925) 18(3.45,-2.275) 19(3.45,-1.625) 20(3.45,-0.975) 21(3.45,-0.325) 22(3.45,0.325) 23(3.45,0.975) 24(3.45,1.625) 25(3.45,2.275) 26(3.45,2.925) 27(3.45,3.575) 28(3.45,4.225)
  silkscreen extent -3.57,-5.3 2,5.3
Sullins_PBC02SAAN [mm] "Sullins 100mil, 1x2, 230 mil above insulator"
  rect 1.65x1.65 hole 1.016: 1(0,1.27)
  round 1.65 hole 1.016: 2(0,-1.27)
  silkscreen extent -1.37,-2.54 1.27,3.1
Testpoint_Keystone_Miniature [mil] "Miniature SMT test point"
  rect 135x70 smd: 1(0,0)
  silkscreen extent -78,-45 78,46
TI_Stacked_Overlay_Small [mil]
TP_H045P075 [mm] "TP_H0.45P0.75"
  round 0.75 hole 0.45: 1(0,0)
WEEE_Minimum [mil] "WEEElie bin"
  silkscreen extent 22,-71 54,74
WL-SMCW_GREEN [mm] "WURTH"
  rect 0.8x0.8 smd: 1(-0.8,0) 2(0.8,0)
  silkscreen extent -1.9,-0.8 1.2,0.8
WL-SMCW_RED [mm] "WURTH"
  rect 0.8x0.8 smd: 1(-0.8,0) 2(0.8,0)
  silkscreen extent -1.9,-0.8 1.2,0.8
WL-SMCW_YELLOW [mm] "WURTH"
  rect 0.8x0.8 smd: 1(-0.8,0) 2(0.8,0)
  silkscreen extent -1.9,-0.8 1.2,0.8
Wurth_60900213421 [mil] "Shunt, 2.54mm, Black"
  round 1 on Mech3: 0(0,0)
WURTH_61300311121 [mm] "Header, 2.54mm, 3x1, TH"
  rrect50% 1.65x1.65 hole 1.15: 1(-2.54,0)
  round 1.65 hole 1.15: 2(0,0) 3(2.54,0)
Wurth_61301421121 [mm] "Header, 2.54mm, 7x2, TH"
  rrect50% 1.65x1.65 hole 1.1: 1(-1.27,7.62)
  round 1.65 hole 1.1: 2(1.27,7.62) 3(-1.27,5.08) 4(1.27,5.08) 5(-1.27,2.54) 6(1.27,2.54) 7(-1.27,0) 8(1.27,0) 9(-1.27,-2.54) 10(1.27,-2.54) 11(-1.27,-5.08) 12(1.27,-5.08) 13(-1.27,-7.62) 14(1.27,-7.62)
XTAL_MS3V-T1R [mm] "Micro Crystal Switzerland recommended land pattern"
  rect 1.1x0.6 smd: 1(-2.775,0.45) 2(-2.775,-0.45)
  rect 2.4x1.5 smd: 3(2.775,0)
  silkscreen extent -1.9,-0.74 1.2,0.74

## Part data
A1 A2 A3 A4 TP13 TP14 TP15 TP16 TP17 TP37 TP38 TP39 TP40 TP41 TP42 TP43 TP44 TP45 TP46: library part CMP-0055149-2, "Test Point, Multipurpose, White, TH"
C1 C2 C3 C4 C5 C6: library part CMP-0006250-2, "CAP, CERM, 33 pF, 50 V, +/- 5%, C0G/NP0, 0402"
C7 C8 C9 C10 C11 C12 C15 C16 C17 C18 C21 C25 C32 C33 C34 C41 C48 C62: library part CMP-0006221-2, "CAP, CERM, 0.1 uF, 10 V, +/- 20%, X5R, 0402"
C13 C29: library part CMP-0097299-1, "0.47 µF ±20% 10V Ceramic Capacitor X5R 0603 (1608 Metric)"
C14 C31: library part CMP-0084376-1, "CAP, Tantalum Polymer, 10 µF, 10 V,+/- 20%, 0.08 ohm, 3216-18 SMD"
C19 C22 C24: library part CMP-0097306-1, "33 pF ±5% 50V Ceramic Capacitor C0G, NP0 0402 (1005 Metric)"
C20: library part CMP-0006269-2, "CAP, CERM, 4.7 uF, 10 V, +/- 20%, X5R, 0402"
C23: library part CMP-0006231-2, "CAP, CERM, 1000 pF, 50 V, +/- 10%, X7R, 0402"
C26 C27 C42 C43: library part CMP-0006215-2, "CAP, CERM, 10 pF, 50 V, +/- 5%, C0G/NP0, 0402"
C28 C30 C47: library part CMP-0078875-1, "CAP, CERM, 0.22 µF, 10 V,+/- 20%, X5R, 0402"
C35 C40 C45: library part CMP-0064924-2, "CAP, CERM, 1 uF, 10 V,+/- 20%, X5R, 0402"
C36: library part CMP-0006562-2, "CAP, CERM, 0.1 uF, 10 V, +/- 10%, X5R, 0402"
C37 C39: library part CMP-0006639-2, "CAP, CERM, 0.01 uF, 16 V, +/- 10%, X7R, 0402"
C38: library part CMP-0006594-2, "CAP, CERM, 2.2 uF, 16 V, +/- 10%, X5R, 0402"
C44: library part CMP-14477-003474-2, "None"
C46: library part CMP-0008271-1, "CAP, CERM, 3.3 uF, 25 V, +/- 10%, X6S, 0805"
C49 C51: library part CMP-0007873-2, "CAP, CERM, 1 uF, 50 V, +/- 10%, X7R, 0805"
C50 C55 C63: library part CMP-0095152-1, "0.1 µF ±10% 100V Ceramic Capacitor X7R 0603 (1608 Metric)"
C52 C54 C60 C61 C64 C65 C66 C74: library part CMP-0097311-1, "1000 pF ±5% 100V Ceramic Capacitor C0G, NP0 0603 (1608 Metric)"
C53 C75: library part CMP-0094051-1, "100uF 100V 20% Aluminum Electrolytic Capacitors Radial, Can - SMD - 5000 Hrs @ 105°C"
C56: library part CMP-0009145-2, "CAP, CERM, 1 uF, 100 V, +/- 10%, X7R, AEC-Q200 Grade 1, 1210"
C57 C58 C59: library part CMP-0079993-1, "CAP, CERM, 0.01 µF, 100 V,+/- 10%, X7R, 0603"
C67 C68 C69 C70 C71: library part CMP-0097308-1, "100 pF ±5% 100V Ceramic Capacitor C0G, NP0 0402 (1005 Metric)"
C72 C73: library part CMP-0006227-2, "CAP, CERM, 0.01 uF, 16 V, +/- 10%, X7R, 0402"
D1: library part CMP-0002947-3, "LED, Red, SMD"
D2 D4 D5 D6 D8 D10 D11: library part CMP-0002894-2, "LED, Green, SMD"
D3: library part CMP-1055-00457-1, "Schottky Barrier Diode, 2-Pin SOD-323, Pb-Free, Tape and Reel"
D7 D12: library part CMP-0002893-1, "LED, Super Red, SMD"
D9 D10 D10 D11 D11 D12 D12: library part CMP-0002892-3, "LED, Yellow, SMD"
D13: library part CMP-0097377-1, "Diode Zener Single 4.7V 2% 550mW Automotive 2-Pin SOD-323F T/R"
F1 F2: library part CMP-0081016-1, "Fuse, 15 A, 250 VAC, 100 VDC, SMD"
FID1 FID2 FID3 FID4: library part CMP-0077181-1, "Fiducial mark.  There is nothing to buy or mount."
H1 H2 H3 H4 H5 H6: library part CMP-0003678-1, "Standoff, Hex, 1.25\"L #6-32 Nylon"
H1_Nut H2_Nut H3_Nut H4_Nut H5_Nut H6_Nut: library part CMP-0003948-1, "Small nylon hex nut, 0.10 thick with a 0.250 outside diameter and a 4-40 threading"
J1 J2: library part CMP-0075613-1, "Receptacle, 2.54mm, 10x2, Gold, TH"
J3 J15 J21 J22 J24: library part CMP-0075110-1, "1mm Uninsulated Shorting Plug, 10.16mm spacing, TH"
J4 J8: library part CMP-0075595-1, "Header, 2.54mm, 8x2, Gold, SMT"
J5 J6 J7 J16 J17 J18 J19 J20 J25 J26: library part CMP-0054566-1, "Header, 100mil, 2x1, Gold, TH"
J9 J10: library part CMP-0086014-1, "Header, 2.54mm, 7x2, Gold, TH"
J11: library part CMP-0055311-1, "Receptacle, USB 2.0, Micro B, 5 Position, R/A, SMT"
J12: library part CMP-0086764-1, "2 Position Wire to Board Terminal Block Horizontal with Board 0.400\" (10.16mm) Through Hole"
J13 J14 J23: library part CMP-0093233-2, "2 Position Wire to Board Terminal Block Horizontal with Board 0.250\" (6.35mm) Through Hole"
J27: library part CMP-0054796-4, "Header, 2.54 mm, 3x1, Gold, TH"
L1 L2: library part CMP-0081962-1, "Ferrite Bead, 150 ohm @ 100 MHz, 0.7 A, 0603"
LBL1: library part CMP-0003625-1, "Thermal Transfer Printable Labels, 0.650\" W x 0.200\" H - 10,000 per roll"
LOGO1 LOGO7: library part CMP-0074837-2, "IEC 61010-1 Hot Surface Warning"
Logo2: library part CMP-0074844-1
Logo3: library part CMP-0074838-1, "Texas Instrument Corporate Signature"
Logo4: library part CMP-0074847-1, "FCC_disclaimer"
Logo5: library part CMP-0074769-3
Logo6: library part CMP-0074836-1, "IEC 61010-1 Caution Warning"
MP1: library part CMP-0096184-1, "Heat Sink Aluminum Top Mount"
Q1: library part CMP-1048-00779-1, "General Purpose Transistor, NPN Silicon, 3-Pin SOT-23, Pb-Free, Tape and Reel"
R1 R5 R6 R7 R8 R9 R10 R11 R12 R13 R14 R15 R16 R17 R18 R21 R23 R24 R25 R26 R27 R30 R32 R33 R34 R54 R62 R63 R68: library part CMP-0026992-3, "RES, 0, 5%, 0.1 W, AEC-Q200 Grade 0, 0402"
R2 R3: library part CMP-0025784-4, "RES, 330 k, 5%, 0.1 W, AEC-Q200 Grade 0, 0603"
R4 R35: library part CMP-0091848-1, "10 Ohms ±5% 0.05W, 1/20W Chip Resistor 0402 (1005 Metric) RF, High Frequency Thin Film"
R19 R44 R49: library part CMP-0021998-4, "RES, 10.0 k, 1%, 0.1 W, AEC-Q200 Grade 0, 0603"
R29 R57 R97: library part CMP-0026935-3, "RES, 47 k, 5%, 0.063 W, AEC-Q200 Grade 0, 0402"
R39 R40 R41 R42: library part CMP-0026071-3, "RES, 1.00 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402"
R55 R60: library part CMP-0026728-1, "RES, 220 k, 1%, 0.0625 W, 0402"
R56: library part CMP-0026190-2, "RES, 240 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402"
R58: library part CMP-0026934-3, "RES, 470, 5%, 0.063 W, AEC-Q200 Grade 0, 0402"
R59: library part CMP-0026948-3, "RES, 560, 5%, 0.063 W, AEC-Q200 Grade 0, 0402"
R61: library part CMP-0026021-3, "RES, 150 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402"
R64 R65 R66 R67: library part CMP-0025963-3, "RES, 10.0, 1%, 0.063 W, AEC-Q200 Grade 0, 0402"
R69 R70: library part CMP-0025697-4, "RES, 0, 5%, 0.1 W, AEC-Q200 Grade 0, 0603"
R71 R72 R73 R75: library part CMP-0026888-3, "RES, 27, 5%, 0.063 W, AEC-Q200 Grade 0, 0402"
R74: library part CMP-2002-00429-1
R76: library part CMP-0026085-3, "RES, 1.40 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402"
R77: library part CMP-0026859-2, "RES, 1.0 M, 5%, 0.063 W, AEC-Q200 Grade 0, 0402"
R78: library part CMP-0026907-3, "RES, 33 k, 5%, 0.063 W, AEC-Q200 Grade 0, 0402"
R79 R80 R81 R82: library part CMP-0026695-1, "RES, 3.30 k, 1%, 0.1 W, AEC-Q200 Grade 0, 0402"
R83 R88 R99 R100 R101 R102 R103 R105 R106 R107 R108 R109: library part CMP-0025886-5, "RES, 10 k, 5%, 0.1 W, 0603"
R84 R85 R86 R87: library part CMP-0081856-1, "RES, 0, 0%, 0.2 W, AEC-Q200 Grade 0, 0402"
R89 R90 R91 R92: library part CMP-0022628-4, "RES, 86.6 k, 1%, 0.1 W, AEC-Q200 Grade 0, 0603"
R93 R94 R95 R96 R104: library part CMP-0022458-4, "RES, 4.99 k, 1%, 0.1 W, AEC-Q200 Grade 0, 0603"
R98: library part CMP-0022663-4, "RES, 97.6 k, 1%, 0.1 W, AEC-Q200 Grade 0, 0603"
R110: library part CMP-0023183-5, "RES, 560, 1%, 0.1 W, 0603"
R111 R112 R113 R114 R115 R116 R117: library part CMP-0025785-4, "RES, 330, 5%, 0.1 W, AEC-Q200 Grade 0, 0603"
R118: library part CMP-0023129-5, "RES, 470, 1%, 0.1 W, 0603"
S1: library part CMP-0097347-1, "Tactile Switch SPST-NO Top Actuated Surface Mount"
SH-J1 SH-J2 SH-J3 SH-J4 SH-J5 SH-J6 SH-J7 SH-J8 SH-J9 SH-J10 SH-J11 SH-J12 SH-J13 SH-J14 SH-J15 SH-J16 SH-J17 SH-J18 SH-J19 SH-J20 SH-J21 SH-J22 SH-J23 SH-J24 SH-J25 SH-J26 SH-J27 SH-J28 SH-J29 SH-J30 SH-J31 SH-J32 SH-J33 SH-J34 SH-J35: library part CMP-0003761-2, "Shunt, 2.54mm, Gold, Black"
TP1 TP2 TP3 TP4 TP5 TP6 TP7 TP8 TP9 TP10 TP11 TP12 TP18 TP19 TP20 TP21 TP22 TP23 TP24 TP26: library part CMP-0003719-1, "Testpoint"
TP25 TP29: library part CMP-0055148-2, "Test Point, Multipurpose, Black, TH"
TP27 TP28 TP30 TP36: library part CMP-0055147-2, "Test Point, Multipurpose, Red, TH"
TP31 TP32 TP34 TP35: library part CMP-0055152-2, "Test Point, Miniature, SMT"
U1: library part CMP-0038879-1, "20 MHz Mixed Signal Microcontroller with 256 KB Flash, 18432 B SRAM and 74 GPIOs, -40 to 85 degC, 100-pin QFP (PZ), Green (RoHS & no Sb/Br)"
U2: library part CMP-0039269-4, "16-Bit Ultra-Low-Power Microcontroller, 128KB Flash, 8KB RAM, USB, 12Bit ADC, 2 USCIs, 32Bit HW MPY, RGC0064B (VQFN-64)"
U3: library part CMP-0036328-3, "500mA, Adjustable, Low Quiescent Current, Low-Noise, High-PSRR, Single-Output LDO Regulator, DRB0008A (VSON-8)"
U4: library part CMP-0004774-1, "USB to Serial UART, SSOP28"
U5: library part CMP-0090815-1, "LDO, Fixed Output, Dual, 3.3V, 10/12/15V, 50mA, Precision Enable, Power-Good, HVSSOP10"
U6: library part CMP-0043099-3, "Low-Capacitance 2-Channel +/-15kV ESD Protection Array for High-Speed Data Interfaces, DRY0006A (USON-6)"
U7: library part CMP-0094088-3, "Quad Half-Bridge Motor Driver with Current Sense Output"
Y1: library part CMP-0085483-1, "Oscillator, 4 MHz, 700 ppm, 39 pF, SMD"
Y2: library part CMP-0004566-4, "Crystal, 32.768 kHz, 12.5pF, SMD"
ZZ1: library part CMP-0003616-3
ZZ2: library part CMP-0077236-1
ZZ3: library part CMP-0077237-1
ZZ4: library part CMP-0077238-1

## Via types
v1: diameter 19.68, hole 13.78, Top Layer to Bottom Layer, tented both sides, 174 vias
v2: diameter 34, hole 16, Top Layer to Bottom Layer, tented both sides, 114 vias
v3: diameter 19.68, hole 7.87, Top Layer to Bottom Layer, 22 vias
v4: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 6 vias
v5: diameter 141.73, hole 141.73, Top Layer to Bottom Layer, tented both sides, 6 vias
v6: diameter 201.73, hole 141.73, Top Layer to Bottom Layer, 2 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point)
3.3V_COM: C41.1 U4.4 U4.17 | length 506.8
  Top Layer w10: U4.4@1853.79,4513.57 1926.78,4513.57 1989.62,4450.73 1989.62,4364.73 2045.51,4308.84 U4.17@2125.44,4308.84 2126.68,4310.08 2223.11,4310.08 C41.1@2224.35,4311.31
A12: A1.1 R5.2 U1.5 | length 7074.3
  Top Layer w10: U1.5@1107.48,2084.13 1107.48,2133.04 1177.04,2202.6 1177.04,2368.91 1439.72,2631.59 1651.52,2631.59 A1.1@1736.04,2716.1 ; v2(6150,3865.91) 6150,3734.84 6320.28,3564.56 R5.2@6320.28,3562.59
  Signal Layer 2 w12: A1.1@1736.04,2716.1 1736.04,2820.41 1977.36,3061.73 1977.36,3383.19 3038.07,4443.9 5684.06,4443.9 6150,3977.95 v2(6150,3865.91)
A13: A2.1 R8.2 U1.6 | length 6779.1
  Top Layer w10: U1.6@1087.8,2084.13 1087.8,2138.63 1159.17,2210 1159.17,2386.19 1482.34,2709.36 A2.1@1546.8,2709.36 ; v2(6150,4100) 6318.06,3931.94 6318.06,3870.75 R8.2@6322.91,3865.91
  Signal Layer 2 w12: A2.1@1560,2724.09 1561.54,2724.09 1957.49,3120.04 1957.49,3391.42 3029.84,4463.77 5786.23,4463.77 v2(6150,4100)
A14: A3.1 R13.2 U1.7 | length 6718.5
  Top Layer w10: U1.7@1068.11,2084.13 1068.11,2144.22 1135.23,2211.34 1135.23,2568.12 1276.47,2709.36 A3.1@1357.57,2709.36 ; v2(6150,4225) 6229.96,4145.04 R13.2@6328.91,4145.04
  Signal Layer 2 w12: A3.1@1357.57,2709.36 1357.57,2830.01 3021.65,4494.09 5880.91,4494.09 v2(6150,4225)
A15: A4.1 R16.2 U1.8 | length 6621.2
  Top Layer w10: U1.8@1048.43,2084.13 1048.43,2149.81 1101.01,2202.4 1101.01,2642.04 A4.1@1168.33,2709.36 ; v2(6150,4520) 6216.28,4453.72 R16.2@6337.15,4453.72
  Signal Layer 2 w12: A4.1@1168.33,2709.36 1175.44,2709.36 1213.25,2747.17 1242.25,2747.17 3015.08,4520 v2(6150,4520)
ACCEL/DECEL: D10.2 U1.37 | length 333.2
  Top Layer w10: D10.2@360.2,1914.51 405.68,1914.51 520.5,1799.69 U1.37@645.87,1799.69
AOUT1/OUT1: C52.2 C60.1 J14.2 J22.2 R89.2 TP31.1 U7.17 U7.18 U7.19 | length 779.8
  Top Layer w10: C52.2@6362.91,3224.28 TP31.1@6524.95,3224.28 ; J14.2@6400.73,2939.62 6524.95,3063.85 TP31.1@6524.95,3224.28 ; R89.2@6524.95,3392.64 TP31.1@6524.95,3224.28 ; TP31.1@6532.84,3228.91 6528.22,3224.28 TP31.1@6524.95,3224.28
  Bottom Layer w10: J14.2@6400.73,2939.62 6404.15,2936.2 C60.1@6404.15,2837.53
AOUT2/OUT2: C60.2 C61.2 J14.1 J24.2 R90.2 TP32.1 U7.14 U7.15 U7.16 | length 1705.2
  Top Layer w10: C61.2@6379.53,2430.84 6534.44,2430.84 TP32.1@6534.91,2431.3 6534.91,2684.62 6529.91,2689.62 ; J14.1@6400.73,2689.62 6529.91,2689.62 ; R90.2@6519.12,3679.85 6520.11,3679.85 6602.11,3597.85 6602.11,2756.83 6534.91,2689.62 6529.91,2689.62
  Bottom Layer w10: J14.1@6400.73,2689.62 6404.15,2693.05 C60.2@6404.15,2790.28
BOUT1/OUT3: C64.2 C65.1 J13.1 J22.1 R91.2 TP34.1 U7.4 U7.5 U7.6 | length 3301.3
  Top Layer w10: C64.2@6173.44,1364.38 6174.38,1364.38 6200.52,1390.52 6520.52,1390.52 TP34.1@6526.91,1396.91 ; J13.1@6400.91,1658.91 6400.91,1522.91 TP34.1@6526.91,1396.91 ; R91.2@6529.39,3969.22 6539.55,3959.05 6539.55,3945.69 6573.82,3911.42 v1(6625,3911.42) ; TP34.1@6538.91,1384.91 TP34.1@6526.91,1396.91 ; TP34.1@6538.91,1408.91 TP34.1@6526.91,1396.91
  Bottom Layer w10: C65.1@6401.91,1755.28 6401.91,1659.91 6400.91,1658.91 6400.91,1676.96 6430.32,1706.37 6458.88,1706.37 6625,1872.49 v1(6625,3911.42)
BOUT2/OUT4: C65.2 C66.2 J13.2 J24.1 R92.2 TP35.1 U7.7 U7.8 U7.9 | length 3246.6
  Top Layer w10: C66.2@6380.53,2325.91 6380.53,2267.33 6446.96,2200.91 TP35.1@6532.91,2200.91 6532.91,1984.91 6456.91,1908.91 J13.2@6400.91,1908.91 ; R92.2@6529.95,4279.35 6530.93,4279.35 6541.68,4268.6 6541.68,4267.61 6589.57,4219.73 v1(6589.57,3943.89)
  Bottom Layer w10: C65.2@6401.91,1802.53 6400.91,1803.53 6400.91,1908.91 6482.91,1908.91 6589.57,2015.57 v1(6589.57,3943.89)
C2K_3V3: J1.1 R1.2 | length 110.6
  Top Layer w10: J1.1@2991.3,143.45 2994.05,140.69 R1.2@3100.74,140.69
C2K_AOUT1: R7.2
C2K_AOUT2: R10.2
C2K_BOUT1: R12.2
C2K_BOUT2: R15.2
C2K_DECAY0/SDI/DECAY/EN1: J2.12 R26.2 | length 283.8
  Top Layer w10: J2.12@1191.3,643.45 1198.16,650.32 1236.81,650.32 1281.37,694.88 1371.8,694.88 1428.38,638.3 R26.2@1430.35,638.3
C2K_DECAY1/SDO/RSVD/EN2: J2.14 R25.2 | length 278.8
  Top Layer w10: J2.14@1191.3,743.45 1199.9,752.05 1227.05,752.05 1275.06,800.06 1365.06,800.06 1406,841 R25.2@1429.67,841
C2K_DIR/IN2/PH2: J2.5 R32.2 | length 144.9
  Top Layer w10: J2.5@1291.3,343.45 1292.28,342.46 1434.41,342.46 R32.2@1435.39,341.48
C2K_ENABLE/IN1/PH1: J1.9 R33.2 | length 107.8
  Top Layer w10: J1.9@2991.3,543.45 2991.69,543.84 3098.38,543.84 R33.2@3098.78,544.24
C2K_IPROPI1/IPROPI2: C4.1 J1.14 R18.2 TP42.1 | length 741.3
  Top Layer w10: R18.2@2627.28,731.24 2727.22,731.24 2730.97,735 2780,735 2788.45,743.45 J1.14@2891.3,743.45 2935.85,788 TP42.1@3345.04,788
C2K_IPROPI2/IPROPI3: C5.1 J1.16 R17.2 TP43.1 | length 941.6
  Top Layer w10: R17.2@2626.33,848.65 2629.99,845 2680,845 2690.26,855.26 C5.1@2728.82,855.26 2819.74,855.26 2831.55,843.45 J1.16@2891.3,843.45 2947.91,900.06 3528.31,900.06 TP43.1@3532.25,904
C2K_M0/nSCS/VREF1/EN4: J2.18 R23.2 | length 280
  Top Layer w10: J2.18@1191.3,943.45 1234.68,900.06 1378.76,900.06 1430.07,951.37 R23.2@1432.03,951.37
C2K_M1/SCLK/IN4/PH4: J1.13 R27.2 | length 109.3
  Top Layer w10: J1.13@2991.3,743.45 2993.46,741.28 3096.61,741.28 R27.2@3098.78,739.12
C2K_MODE2/IPROPI4: C6.1 J1.18 R14.2 TP44.1 | length 771.4
  Top Layer w10: R14.2@2626.33,947.78 2629.11,945 2660,945 2688.37,973.37 C6.1@2728.82,973.37 2856.85,973.37 2886.77,943.45 J1.18@2891.3,943.45 2938.8,990.95 3344.68,990.95 TP44.1@3350.39,985.24
C2K_MODE/MODE1: J2.13 R11.2 | length 144.1
  Top Layer w10: J2.13@1291.3,743.45 R11.2@1435.39,743.45
C2K_nFAULT: J1.15 R6.2 | length 108.7
  Top Layer w10: J1.15@2991.3,843.45 2992.77,844.93 3097.3,844.93 R6.2@3098.78,846.4
C2K_nHOME/OCPM: J2.1 R9.2 | length 145.3
  Top Layer w10: J2.1@1292.32,144.09 1297.69,138.72 R9.2@1435.39,138.72
C2K_nSLEEP: J2.7 R34.2 | length 145.1
  Top Layer w10: J2.7@1291.3,443.45 1292.48,444.63 1434.21,444.63 R34.2@1435.39,445.81
C2K_RSVD/IPROPI1: C3.1 J1.12 R21.2 TP41.1 | length 952
  Top Layer w10: R21.2@2626.33,615.26 2727.45,615.26 C3.1@2728.82,616.63 2730.46,615 2790,615 2818.45,643.45 J1.12@2891.3,643.45 2942.85,695 3425,695 3456,726 TP41.1@3531.16,726
C2K_STEP/IN3/PH3: J2.20 R30.2 | length 258.3
  Top Layer w10: J2.20@1191.3,1043.45 1199.53,1051.69 1238.18,1051.69 1274.69,1088.2 1428.52,1088.2 R30.2@1430.32,1090
C2K_TOFF/RSVD/EN3: J2.3 R24.2 | length 145.1
  Top Layer w10: J2.3@1299.53,238.38 R24.2@1444.59,238.38
C2K_VREF: J1.20 R19.1 TP45.1 | length 824.9
  Top Layer w10: R19.1@2763,1127 2763.99,1127 2845.78,1045.2 2889.54,1045.2 J1.20@2891.3,1043.45 2934.68,1086.83 3528.52,1086.83 TP45.1@3533.35,1082
DIR/IN2: J8.6 R32.1 U7.27 | length 6088.4
  Top Layer w10: R32.1@1474.76,341.48 1476.73,341.48 1481.57,346.32 1481.57,348.29 2480,1346.72 v2(2480,1530) ; J8.6@2600,3460 3132.53,3460 3962.75,2629.78 3962.75,2613.08 4363.33,2212.5 U7.27@4437.36,2212.5
  Bottom Layer w10: v2(2480,1530) 2480,2647.25 2935,3102.25 v2(2935,3460)
DM: R73.2 U4.16 | length 420.9
  Top Layer w10: R73.2@1741.97,4251.15 1771.12,4222 1991.85,4222 2053.1,4283.25 U4.16@2125.44,4283.25
DP: R71.2 U4.15 | length 430.4
  Top Layer w10: R71.2@1741.35,4188.18 2085.88,4188.18 2125.44,4227.74 U4.15@2125.44,4257.66
DRV_ENABLE: D9.2 U1.36 | length 403.6
  Top Layer w10: D9.2@360.24,2040.05 360.24,1994.76 535.63,1819.37 U1.36@645.87,1819.37
DVDD: C49.2 TP28.1 U7.43 | length 1346.2
  Top Layer w10: C49.2@3529.53,2547.6 3532.13,2545 TP28.1@3665.42,2545 ; v2(4180.12,1808.07) 4182.33,1810.29 4435.15,1810.29 U7.43@4437.36,1812.5
  Signal Layer 2 w15: TP28.1@3665.42,2545 3665.42,2322.77 v2(4180.12,1808.07)
EN4: D12.2 U1.40 | length 319.3
  Top Layer w10: D12.2@359.29,1661.57 412.48,1661.57 491.54,1740.63 U1.40@645.87,1740.63
ENABLE/IN1: J8.4 R33.1 U7.26 | length 4824
  Top Layer w10: J8.4@2600,3560 3058.08,3560 4110,2508.08 v2@4110,2501.4 ; R33.1@3138.15,544.24 3140.26,542.12 3247.88,542.12 v2(3250,540) ; v2(4114.04,2504.04) 4380.58,2237.5 U7.26@4437.36,2237.5
  Bottom Layer w10: v2(3250,540) 3250,1175 3465.92,1390.92 cw(c3520,1375) 3504.08,1429.08 4055,1980 4055,2445 v2(4114.04,2504.04)
EVM_STATUS: D6.2 U1.34 | length 600.8
  Top Layer w10: D6.2@359.8,2285.58 359.8,2249.34 400,2209.14 400,2094.42 420,2074.42 420,1990 551.26,1858.74 U1.34@645.87,1858.74
EZFET_AVBUS: C24.1 R56.1 R61.2 U2.1 | length 482.9
  Top Layer w6: 782.32,4577.36 783.14,4578.18 783.14,4595.46 783.14,4599.22 783.14,4643.56 R56.1@786.37,4646.78 ; C24.1@782.89,4547.39 782.32,4547.97 782.32,4578.18 782.32,4595.46 R61.2@786.08,4599.22 ; 819.67,4407.58 926.18,4301.07 U2.1@926.18,4252.1
  Top Layer w10: C24.1@782.89,4547.39 802.81,4527.48 802.81,4526.12 808.87,4526.12 819.67,4515.32 819.67,4407.58
EZFET_AVCC2ADC: C22.1 R55.1 R60.2 U2.2 | length 356.3
  Top Layer w6: C22.1@782.43,4390.81 782.43,4368.21 793.64,4356.99 793.64,4355.89 801.77,4347.76 849.89,4347.76 912.26,4285.4 912.26,4270.26 904.44,4262.44 904.44,4251.78 907.25,4248.97 907.25,4243.19 U2.2@912.26,4238.18 ; C22.1@784.6,4390.81 782.43,4392.98 R60.2@782.43,4446.4 ; R60.2@786.37,4442.46 R60.2@782.43,4446.4 ; R55.1@786.37,4491.87 782.43,4491.87 R60.2@782.43,4450.11 ; R60.2@782.43,4446.4 R60.2@782.43,4450.11 ; R60.2@782.43,4446.4 R60.2@782.43,4450.11
EZFET_D_N: C42.1 R72.2 U2.52 | length 617
  Top Layer w10: U2.52@1129.4,4085.07 1132.36,4085.07 1132.36,4090.31 1136.93,4094.89 1247.53,4094.89 1329.13,4176.49 1417.7,4176.49 C42.1@1498.87,4257.66 1498.87,4421.53 R72.2@1505.29,4427.95
EZFET_D_P: C43.1 R75.2 R76.1 R77.2 U2.50 | length 675.1
  Top Layer w10: U2.50@1157.24,4057.23 1159.8,4057.23 1159.8,4062.74 1164.12,4067.05 1268.56,4067.05 R76.1@1285.53,4084.03 1285.53,4085.59 R77.2@1314,4114.06 1314,4121.64 1391.13,4121.64 1495.59,4226.1 1530.04,4226.1 1554.42,4250.47 C43.1@1554.42,4257.66 1546.25,4265.83 1546.25,4427.25 1554.42,4427.25 R75.2@1553.72,4427.95
EZFET_LED0: R58.2 U2.20 | length 334.1
  Top Layer w10: R58.2@504.92,4149.61 504.92,4145.67 695.06,3955.53 748.93,3955.53 U2.20@754.14,3960.74
EZFET_LED1: R59.2 U2.21 | length 413.2
  Top Layer w10: R59.2@455.71,4149.61 455.71,4145.67 663.72,3937.66 758.9,3937.66 772.68,3951.44 U2.21@773.07,3951.44
EZFET_PUR: R76.2 U2.51 | length 282.9
  Top Layer w6: v1(1121.45,4048.93) 1143.32,4070.81 U2.51@1143.32,4071.34
  Top Layer w10: v1(1246.35,3984.64) 1252.95,3984.64 1294.35,4026.03 R76.2@1318.94,4050.62
  Bottom Layer w10: v1(1121.45,4048.93) 1151.9,4048.93 1216.2,3984.64 v1(1246.35,3984.64)
EZFET_RST: C23.1 J9.11 R57.1 U2.64 | length 1323.1
  Top Layer w10: C23.1@532.35,4568.4 R57.1@593.25,4568.4 596.35,4571.51 596.35,4671.64 600.35,4675.64 ; J9.11@670.78,4892.4 621.17,4842.8 510.51,4842.8 480.19,4812.48 480.19,4729.8 534.35,4675.64 596.35,4675.64 600.35,4675.64 ; U2.64@962.37,4252.1 962.37,4252.3 974.26,4264.18 974.26,4282.23 838.87,4417.62 838.87,4641.48 804.71,4675.64 600.35,4675.64
EZFET_TCK: J9.7 U2.63 | length 899.5
  Top Layer w10: J9.7@867.11,4890.24 819.67,4842.8 755.53,4842.8 721.76,4809.03 721.76,4771.46 748.32,4744.89 801.73,4744.89 856.74,4689.88 856.74,4441.39 992.13,4306 992.13,4254.22 U2.63@976.29,4238.38
EZFET_TDI: J9.3 U2.61 | length 839
  Top Layer w10: U2.61@1004.13,4210.54 1027.88,4234.29 1027.88,4321.6 921.76,4427.72 921.76,4507.82 927.62,4513.68 927.62,4575.87 921.76,4581.73 921.76,4813.85 947.16,4839.26 1016.12,4839.26 J9.3@1067.11,4890.24
EZFET_TDO: J9.1 U2.60 | length 870.4
  Top Layer w10: U2.60@1018.05,4196.62 1029.94,4208.51 1029.94,4211.06 1045.75,4226.89 1045.75,4330.6 954.63,4421.72 954.63,4708.05 953.68,4709.01 983.51,4738.84 1021.76,4777.09 1021.76,4811.01 1050,4839.26 1116.12,4839.26 J9.1@1167.11,4890.24
EZFET_TEST: J9.8 U2.59 | length 726
  Top Layer w10: J9.8@870.78,4792.4 902.35,4760.83 v1@902.35,4547 ; v1(1010.14,4157.8) 1010.14,4160.87 1031.87,4182.6 U2.59@1031.97,4182.7
  Bottom Layer w10: v1(902.96,4547) 902.96,4264.98 v1(1010.14,4157.8)
EZFET_TMS: J9.5 U2.62 | length 852.8
  Top Layer w10: J9.5@967.11,4890.24 921.12,4844.26 851.78,4844.26 821.76,4814.23 821.76,4771.46 877.27,4715.94 877.27,4446.92 1010.01,4314.19 1010.01,4244.25 U2.62@990.21,4224.46
EZFET_UARTRXD: R66.1 R70.2 U2.38 | length 1322.4
  Top Layer w10: U2.38@1031.97,3868.12 1057.02,3843.06 1057.02,3801.44 v1(1058.52,3799.94) 1058.52,3648.63 R66.1@1038.75,3628.85 ; v1@1693.86,4428.25 R70.2@1693.86,4488.9
  Bottom Layer w10: v1(1058.52,3799.94) 1175.58,3917 1356.35,3917 1694.35,4255 v1(1694.35,4434)
EZFET_UARTTXD: R67.1 R69.1 U2.37 | length 1424.8
  Top Layer w10: R67.1@938.47,3628.8 1029.94,3720.26 1029.94,3842.31 U2.37@1018.05,3854.2 ; v1(1665.88,4526) 1665.88,4560.07 1664.96,4560.98 1692.59,4588.61 R69.1@1692.59,4594
  Bottom Layer w10: v1(1030.96,3819) v1(1030.96,3819) 1160.24,3948.21 1342.41,3948.21 1665.88,4271.68 v1(1665.88,4526)
EZFET_USB_Shield: C47.1 J11.6 J11.7 J11.8 J11.9 J11.10 J11.11 R78.2 | length 817.3
  Top Layer w10: J11.10@1354.7,4906.19 J11.9@1473.3,4906.19 ; J11.11@1413.26,4815.63 1413.26,4827.94 1451.23,4865.91 1451.23,4884.12 J11.9@1473.3,4906.19 ; J11.8@1547.12,4906.19 J11.8@1547.12,4875.67 ; J11.7@1665.72,4906.19 1665.72,4886.5 1607.16,4827.94 J11.6@1607.16,4815.63 ; R78.2@1786.73,4861 1786.73,4818.53 C47.1@1786.73,4798.03 1780.63,4804.13 1618.66,4804.13 J11.6@1607.16,4815.63 ; J11.9@1473.3,4906.19 1525.05,4906.19 1547.12,4884.12 J11.8@1547.12,4875.67 ; J11.8@1547.12,4875.67 1549.01,4873.78 1569.19,4873.78 1583.12,4859.85 1583.12,4839.67 J11.6@1607.16,4815.63
EZFET_V18: C28.1 U2.55 | length 131.5
  Top Layer w10: U2.55@1087.65,4127.02 1128.65,4167.94 1128.65,4193.64 1140.35,4205.34 C28.1@1162.5,4227.49
EZFET_VBUS: C20.1 C21.1 C35.1 C36.1 C37.1 C48.1 D3.1 R56.2 U2.53 U3.5 U3.8 U4.20 U6.1 | length 3000.8
  Top Layer w10: v1(704.92,4646.78) R56.2@735.19,4646.78 ; U2.53@1115.49,4099.18 1170.78,4152.66 ; 1171.41,4152.03 1212.03,4152.03 C20.1@1225.05,4165.04 1236.05,4154.04 v1(1274.35,4154.04) ; v1(1209.61,4502.62) C35.1@1237.17,4502.62 ; C35.1@1240.16,4501.97 1241.14,4500.98 C36.1@1296.26,4500.98 ; v1(1305.31,3994) 1378.94,3920.37 C21.1@1378.94,3917.41 ; v1(2048.06,4385.61) U4.20@2125.44,4385.61
  Top Layer w12: U3.8@1366.66,4419.89 1366.56,4419.99 1366.56,4425.7 1310.8,4481.45 1310.8,4482.5 1301.09,4492.22 1301.09,4496.16 1297.7,4499.55 1299.63,4501.48 1347.93,4501.48 C37.1@1348.43,4500.99 1348.43,4504.92 1354.24,4510.73 1372,4510.73 1388.45,4527.18 1412.45,4527.18 1418.26,4532.99 1418.26,4540.87 1424.07,4546.68 1429.19,4546.68 1446.1,4563.6 v1(1448.18,4563.6) 1448.18,4565.67 1437.08,4576.78 1437.08,4661.69 1443.48,4668.09 1467.48,4668.09 U6.1@1481.29,4681.89 ; U3.8@1366.66,4425.6 1366.76,4425.7 1366.76,4430.79 1381.54,4445.57 1428.55,4445.57 1443.33,4430.79 1443.33,4419.99 U3.5@1443.43,4419.89
  Bottom Layer w10: v1(704.92,4646.78) 706.77,4644.93 719.54,4644.93 742.61,4621.86 1120.19,4621.86 1209.61,4532.44 v1(1209.61,4502.62) ; v1(1305.31,3994) 1275.22,4024.1 1271.63,4024.1 1271.63,4151.32 v1(1274.35,4154.04) 1316.75,4196.44 1316.75,4266.08 1262.24,4320.59 1262.24,4380.41 1445.43,4563.6 v1(1448.18,4563.6) 1448.18,4563.5 1462.89,4548.79 1848.68,4548.79 2008.74,4388.73 v1@2047.62,4388.73
EZFET_VCC: C31.1 C32.1 C33.1 C34.1 J10.9 R55.2 R57.2 R62.1 R63.1 R68.2 R74.2 U2.11 U2.15 U2.40 | length 3040
  Top Layer w10: C31.1@664.94,4152.31 747.78,4152.31 ; v1@690.83,4104.97 692.68,4103.12 692.68,4095.85 U2.15@726.49,4062.04 ; U2.11@782.27,4117.82 747.78,4152.31 ; C32.1@792.96,4242.63 792.96,4238.7 786.15,4231.89 755.73,4231.89 740.58,4216.73 740.58,4199.2 v1(738.72,4197.35) 740.58,4195.49 740.58,4172.87 747.78,4165.67 747.78,4152.31 ; U2.40@1059.81,3895.96 1077.09,3878.67 1101.33,3878.67 1130,3850 1131.95,3850 v1(1150.21,3831.74) 1150.21,3781.99 C34.1@1138.67,3770.46
  Top Layer w15: R57.2@593.25,4521.16 596.78,4521.16 597.56,4520.38 675.96,4520.38 704.47,4491.87 R55.2@735.19,4491.87 ; C31.1@661.3,4148.66 669.18,4148.66 689.23,4128.6 689.23,4108.22 690.83,4106.62 v1(690.83,4105.36) ; v1(977.35,4583) 978.25,4582.1 1103.16,4582.1 1105.5,4579.76 R62.1@1105.5,4579.53 R63.1@1146.88,4579.53
  Top Layer w20: v1(1470.63,3973.24) R74.2@1470.63,4019.83 1471.46,4020.66 1471.46,4054.01 1483.18,4065.73 1506.69,4065.73 1506.85,4065.88 R68.2@1506.85,4066.36
  Bottom Layer w14: v1(705.26,4491.87) 748.96,4491.87 ; v1(738.72,4197.35) 738.72,4340.26 748.96,4350.5 748.96,4491.87 ; v1(977.35,4583) 840.09,4583 748.96,4491.87
  Bottom Layer w20: v1(690.83,4105.36) 699.64,4105.36 1090.47,3714.53 ; J10.9@896.35,3460.02 904.95,3468.62 904.95,3529.01 1090.47,3714.53 ; v1(1470.63,3973.24) 1391.52,3894.13 1212.59,3894.13 v1(1150.21,3831.74) 1146.56,3828.09 1146.56,3770.61 1090.47,3714.53
EZFET_VCORE: C29.1 U2.17 | length 213.9
  Top Layer w10: C29.1@572.75,4151.42 578.82,4145.35 578.82,4128.72 633.5,4074.04 650.66,4074.04 U2.17@717.29,4007.41
EZFET_VREF: C25.1 U2.9 | length 138.9
  Top Layer w10: 797.99,4185.47 797.99,4157.77 U2.9@814.83,4140.94 ; 797.99,4185.47 836.32,4223.79 836.32,4248.51 C25.1@842.35,4254.54
EZFET_VUSB: C30.1 U2.54 | length 124
  Top Layer w10: U2.54@1101.57,4113.1 1149.42,4160.87 C30.1@1190.02,4199.93
EZFET_XT2IN: U2.57 Y1.1 | length 201.2
  Top Layer w10: U2.57@1059.81,4154.86 1085.37,4180.43 1085.37,4256.4 Y1.1@1148.37,4319.39
EZFET_XT2OUT: U2.58 Y1.3 | length 234
  Top Layer w10: U2.58@1045.89,4168.78 1065.04,4187.93 1065.04,4343.67 1053.88,4354.83 Y1.3@1053.88,4390.26