# Altium project MD040EVM_RevA.PrjPCB (part 2 of 2)

## Sheet MD040_Motor_control_RevA.SchDoc
size 431 x 279 mm; Date: Not shown in title block; ApprovedBy: Not shown in title block; CheckedBy: Not shown in title block; Author: Not shown in title block; CompanyName: Not shown in title block; DrawnBy: ak; Engineer: Not shown in title block; Organization: Not shown in title block; Address1: Not shown in title block; Address2: Not shown in title block; Address3: Not shown in title block; Address4: Not shown in title block; DocumentNumber: 2; Revision: Use project parameter SCH_Rev; SheetNumber: 3; SheetTotal: 2; PageSetup: Record=PageOptions¦CenterHorizontal=True¦CenterVertical=True¦PrintScale=1.00¦XCorrection=1.00¦YCorrection=1.00¦PrintKind=0¦BorderSize=5000000¦LeftOffset=0¦BottomOffset=0¦Orientation=2¦PaperLength=1000¦PaperWidth=1000¦Scale=100¦PaperSource=15¦PrintQuality=600¦MediaType=1¦DitherType=10¦PaperKind=Letter¦PrintScaleMode=1

### Parts
A1  5012  [Keystone5012]  (value not drawn)
A2  5012  [Keystone5012]  (value not drawn)
A3  5012  [Keystone5012]  (value not drawn)
A4  5012  [Keystone5012]  (value not drawn)
C1  VDC_V: 50V  ValueDisplayed: 33pF  [0402]  (hidden comment: C1005C0G1H330J050BA)
C2  VDC_V: 50V  ValueDisplayed: 33pF  [0402]  (hidden comment: C1005C0G1H330J050BA)
C3  VDC_V: 50V  ValueDisplayed: 33pF  [0402]  (hidden comment: C1005C0G1H330J050BA)
C4  VDC_V: 50V  ValueDisplayed: 33pF  [0402]  (hidden comment: C1005C0G1H330J050BA)
C5  VDC_V: 50V  ValueDisplayed: 33pF  [0402]  (hidden comment: C1005C0G1H330J050BA)
C6  VDC_V: 50V  ValueDisplayed: 33pF  [0402]  (hidden comment: C1005C0G1H330J050BA)
C7  ValueDisplayed: 0.1uF  [0402L]  (hidden comment: 885012105010)
C8  ValueDisplayed: 0.1uF  [0402L]  (hidden comment: 885012105010)
C9  ValueDisplayed: 0.1uF  [0402L]  (hidden comment: 885012105010)
C10  ValueDisplayed: 0.1uF  [0402L]  (hidden comment: 885012105010)
C11  ValueDisplayed: 0.1uF  [0402L]  (hidden comment: 885012105010)
C12  ValueDisplayed: 0.1uF  [0402L]  (hidden comment: 885012105010)
C13  ValueDisplayed: 470nF  VDC_V: 10V  [FP-885012106008_0603-MFG]  (hidden comment: 885012106008)
C14  VDC_V: 10V  ValueDisplayed: 10µF  [3216-18]  (hidden comment: T520A106M010ATE080)
C15  ValueDisplayed: 0.1uF  [0402L]  (hidden comment: 885012105010)
C16  VDC_V: 10V  ValueDisplayed: 0.1uF  [0402]  (hidden comment: 885012105010)
C17  VDC_V: 10V  ValueDisplayed: 0.1uF  [0402]  (hidden comment: 885012105010)
C18  VDC_V: 10V  ValueDisplayed: 0.1uF  [0402]  (hidden comment: 885012105010)
C19  ValueDisplayed: 33pF  VDC_V: 50V  [FP-885012005058_0402-MFG]  (hidden comment: 885012005058)
C62  ValueDisplayed: 0.1uF  [0402L]  (hidden comment: 885012105010)
C72  VDC_V: 16V  ValueDisplayed: 0.01uF  [0402]  (hidden comment: 885012205031)
C73  VDC_V: 16V  ValueDisplayed: 0.01uF  [0402]  (hidden comment: 885012205031)
C74  1.1 nF  [FP-C0805C-DN-MFG]
J1  CMP-0075613-1  [Samtec_SSQ-110-03-x-D]
J2  CMP-0075613-1  [Samtec_SSQ-110-03-x-D]
J3  61301421121  [Wurth_61301421121]
J4  TSM-108-01-L-DV  [Samtec_TSM-108-01-x-DV]  (value not drawn)
J5  PBC02SAAN  [Sullins_PBC02SAAN]  (value not drawn)
J6  PBC02SAAN  [Sullins_PBC02SAAN]  (value not drawn)
J7  PBC02SAAN  [Sullins_PBC02SAAN]  (value not drawn)
J8  TSM-108-01-L-DV  [Samtec_TSM-108-01-x-DV]  (value not drawn)
J25  PBC02SAAN  [Sullins_PBC02SAAN]  (value not drawn)
J26  PBC02SAAN  [Sullins_PBC02SAAN]  (value not drawn)
R1  value 0  [0402L]  (hidden comment: Resistor)
R2  ValueDisplayed: 330k  [0603L]  (hidden comment: CRCW0603330KJNEA)
R3  ValueDisplayed: 330k  [0603L]  (hidden comment: CRCW0603330KJNEA)
R4  Res_ohm: 10  [FP-CH0402-10RJFPT_0402-MFG]  (hidden comment: CH0402-10RJFPT)
R5  value 0  [0402L]  (hidden comment: Resistor)
R6  value 0  [0402L]  (hidden comment: Resistor)
R7  value 0  [0402L]  (hidden comment: Resistor)
R8  value 0  [0402L]  (hidden comment: Resistor)
R9  value 0  [0402L]  (hidden comment: Resistor)
R10  value 0  [0402L]  (hidden comment: Resistor)
R11  value 0  [0402L]  (hidden comment: Resistor)
R12  value 0  [0402L]  (hidden comment: Resistor)
R13  value 0  [0402L]  (hidden comment: Resistor)
R14  value 0  [0402L]  (hidden comment: Resistor)
R15  value 0  [0402L]  (hidden comment: Resistor)
R16  value 0  [0402L]  (hidden comment: Resistor)
R17  value 0  [0402L]  (hidden comment: Resistor)
R18  value 0  [0402L]  (hidden comment: Resistor)
R19  ValueDisplayed: 10.0k  [0603]  (hidden comment: CRCW060310K0FKEA)
R20  value 0  [0402L]  (hidden comment: Resistor)
R21  value 0  [0402L]  (hidden comment: Resistor)
R22  value 0  [0402L]  (hidden comment: Resistor)
R23  value 0  [0402L]  (hidden comment: Resistor)
R24  value 0  [0402L]  (hidden comment: Resistor)
R25  value 0  [0402L]  (hidden comment: Resistor)
R26  value 0  [0402L]  (hidden comment: Resistor)
R27  value 0  [0402L]  (hidden comment: Resistor)
R29  ValueDisplayed: 47k  [0402]  (hidden comment: CRCW040247K0JNED)
R30  value 0  [0402L]  (hidden comment: Resistor)
R32  value 0  [0402L]  (hidden comment: Resistor)
R33  value 0  [0402L]  (hidden comment: Resistor)
R34  value 0  [0402L]  (hidden comment: Resistor)
R35  Res_ohm: 10  [FP-CH0402-10RJFPT_0402-MFG]  (hidden comment: CH0402-10RJFPT)
R39  ValueDisplayed: 1.00k  [0402L]  (hidden comment: CRCW04021K00FKED)
R40  ValueDisplayed: 1.00k  [0402L]  (hidden comment: CRCW04021K00FKED)
R41  ValueDisplayed: 1.00k  [0402L]  (hidden comment: CRCW04021K00FKED)
R42  ValueDisplayed: 1.00k  [0402L]  (hidden comment: CRCW04021K00FKED)
R44  ValueDisplayed: 10.0k  [0603]  (hidden comment: CRCW060310K0FKEA)
R49  ValueDisplayed: 10.0k  [0603]  (hidden comment: CRCW060310K0FKEA)
R54  value 0  [0402L]  (hidden comment: Resistor)
SH-J1  60900213421  [Wurth_60900213421]  (value not drawn)
SH-J2  60900213421  [Wurth_60900213421]  (value not drawn)
SH-J3  60900213421  [Wurth_60900213421]  (value not drawn)
SH-J4  60900213421  [Wurth_60900213421]  (value not drawn)
SH-J5  60900213421  [Wurth_60900213421]  (value not drawn)
SH-J6  60900213421  [Wurth_60900213421]  (value not drawn)
SH-J7  60900213421  [Wurth_60900213421]  (value not drawn)
SH-J8  60900213421  [Wurth_60900213421]  (value not drawn)
SH-J9  60900213421  [Wurth_60900213421]  (value not drawn)
SH-J10  60900213421  [Wurth_60900213421]  (value not drawn)
SH-J11  60900213421  [Wurth_60900213421]  (value not drawn)
SH-J12  60900213421  [Wurth_60900213421]  (value not drawn)
SH-J13  60900213421  [Wurth_60900213421]  (value not drawn)
SH-J14  60900213421  [Wurth_60900213421]  (value not drawn)
SH-J15  60900213421  [Wurth_60900213421]  (value not drawn)
SH-J16  60900213421  [Wurth_60900213421]  (value not drawn)
SH-J17  60900213421  [Wurth_60900213421]  (value not drawn)
SH-J30  60900213421  [Wurth_60900213421]  (value not drawn)
SH-J31  60900213421  [Wurth_60900213421]  (value not drawn)
TP1  TP_H0.45P0.75  [TP_H045P075]  (value not drawn)  (no BOM)
TP2  TP_H0.45P0.75  [TP_H045P075]  (value not drawn)  (no BOM)
TP3  TP_H0.45P0.75  [TP_H045P075]  (value not drawn)  (no BOM)
TP4  TP_H0.45P0.75  [TP_H045P075]  (value not drawn)  (no BOM)
TP5  TP_H0.45P0.75  [TP_H045P075]  (value not drawn)  (no BOM)
TP6  TP_H0.45P0.75  [TP_H045P075]  (value not drawn)  (no BOM)
TP7  TP_H0.45P0.75  [TP_H045P075]  (value not drawn)  (no BOM)
TP8  TP_H0.45P0.75  [TP_H045P075]  (value not drawn)  (no BOM)
TP9  TP_H0.45P0.75  [TP_H045P075]  (value not drawn)  (no BOM)
TP10  TP_H0.45P0.75  [TP_H045P075]  (value not drawn)  (no BOM)
TP11  TP_H0.45P0.75  [TP_H045P075]  (value not drawn)  (no BOM)
TP12  TP_H0.45P0.75  [TP_H045P075]  (value not drawn)  (no BOM)
TP13  5012  [Keystone5012]  (value not drawn)
TP14  5012  [Keystone5012]  (value not drawn)
TP15  5012  [Keystone5012]  (value not drawn)
TP16  5012  [Keystone5012]  (value not drawn)
TP17  5012  [Keystone5012]  (value not drawn)
TP18  TP_H0.45P0.75  [TP_H045P075]  (value not drawn)  (no BOM)
TP19  TP_H0.45P0.75  [TP_H045P075]  (value not drawn)  (no BOM)
TP20  TP_H0.45P0.75  [TP_H045P075]  (value not drawn)  (no BOM)
TP21  TP_H0.45P0.75  [TP_H045P075]  (value not drawn)  (no BOM)
TP22  TP_H0.45P0.75  [TP_H045P075]  (value not drawn)  (no BOM)
TP23  TP_H0.45P0.75  [TP_H045P075]  (value not drawn)  (no BOM)
TP24  TP_H0.45P0.75  [TP_H045P075]  (value not drawn)  (no BOM)
TP25  5011  [Keystone5011]  (value not drawn)
TP26  TP_H0.45P0.75  [TP_H045P075]  (value not drawn)  (no BOM)
TP27  5010  [Keystone5010]  (value not drawn)
TP37  5012  [Keystone5012]  (value not drawn)
TP38  5012  [Keystone5012]  (value not drawn)
TP39  5012  [Keystone5012]  (value not drawn)
TP40  5012  [Keystone5012]  (value not drawn)
TP41  5012  [Keystone5012]  (value not drawn)
TP42  5012  [Keystone5012]  (value not drawn)
TP43  5012  [Keystone5012]  (value not drawn)
TP44  5012  [Keystone5012]  (value not drawn)
TP45  5012  [Keystone5012]  (value not drawn)
TP46  5012  [Keystone5012]  (value not drawn)
U1  MSP430F5338IPZ  [PZT0100A_N]
Y2  MS3V-T1R 32.768KHZ +/-20PPM 12.5PF  [XTAL_MS3V-T1R]  (value not drawn)

### Nets
C2K_3V3: J1.1 R1.2
GND: C1.2 C2.2 C3.2 C4.2 C5.2 C6.2 C7.1 C8.1 C9.1 C10.1 C11.1 C12.2 C13.2 C14.2(-) C15.1 C16.2 C17.2 C18.2 C19.2 C62.1 C72.2 C73.1 C74.2 J1.4 J2.2 J3.9 R49.1 TP25.1 U1.10(P5.1/VREF-/VEREF-) U1.12(AVSS1) U1.15(AVSS2) U1.26(DVSS1) U1.29(DVSS) U1.63(DVSS2) U1.76(VSSU) U1.83(AVSS3) U1.90(DVSS3) Y2.3(GND)
MCU_3V3: C12.1 C14.1(+) C16.1 C17.1 C18.1 R1.1 R4.1 R20.2 R22.2 R29.1 R35.1 R44.2 TP27.1 U1.25(DVCC1) U1.64(DVCC2) U1.87(VBAT) U1.89(DVCC3)
A12: A1.1 R5.2 U1.5(P7.4/CB8/A12)
A13: A2.1 R8.2 U1.6(P7.5/CB9/A13)
A14: A3.1 R13.2 U1.7(P7.6/CB10/A14/DAC0)
A15: A4.1 R16.2 U1.8(P7.7/CB11/A15/DAC1)
ACCEL/DECEL: U1.37(P1.3/TA0.2)
C2K_AOUT1: R7.2
C2K_AOUT2: R10.2
C2K_BOUT1: R12.2
C2K_BOUT2: R15.2
C2K_DECAY0/SDI/DECAY/EN1: J2.12 R26.2
C2K_DECAY1/SDO/RSVD/EN2: J2.14 R25.2
C2K_DIR/IN2/PH2: J2.5 R32.2
C2K_ENABLE/IN1/PH1: J1.9 R33.2
C2K_IPROPI1/IPROPI2: C4.1 J1.14 R18.2 TP42.1
C2K_IPROPI2/IPROPI3: C5.1 J1.16 R17.2 TP43.1
C2K_M0/nSCS/VREF1/EN4: J2.18 R23.2
C2K_M1/SCLK/IN4/PH4: J1.13 R27.2
C2K_MODE2/IPROPI4: C6.1 J1.18 R14.2 TP44.1
C2K_MODE/MODE1: J2.13 R11.2
C2K_nFAULT: J1.15 R6.2
C2K_nHOME/OCPM: J2.1 R9.2
C2K_nSLEEP: J2.7 R34.2
C2K_RSVD/IPROPI1: C3.1 J1.12 R21.2 TP41.1
C2K_STEP/IN3/PH3: J2.20 R30.2
C2K_TOFF/RSVD/EN3: J2.3 R24.2
C2K_VREF: J1.20 R19.1 TP45.1
DIR/IN2: J8.12 R32.1
DRV_ENABLE: U1.36(P1.2/TA0.1)
ENABLE/IN1: J8.14 R33.1
EVM_STATUS: U1.34(P1.0/TA0CLK/ACLK)
FAULT: U1.40(P1.6/TA0.1)
GUI_STATUS: U1.35(P1.1/TA0.0)
ID1: U1.33(P5.5)
ID2: U1.32(P5.4)
ID3: U1.31(P5.3)
ID4: U1.84(P7.2/XT2IN)
ID5: U1.85(P7.3/XT2OUT)
INDEXER HOME: U1.39(P1.5/TA0.4)
M0/nSCS/VREF1/EN4_2: J4.16 J26.2
MANUAL_VREF: C19.1 J7.2 R44.1 R49.2
MCU_UARTRXD: U1.61(P8.3/UCA1RXD/UCA1SOMI)
MCU_UARTTXD: U1.60(P8.2/UCA1TXD/UCA1SIMO)
MODE2/IPROPI4: J4.8 R14.1
MODE/MODE1: J4.6 R11.1
MSP_DECAY0/SDI/DECAY/EN1: J8.5 U1.65(P8.5/UCB1SIMO/UCB1SDA)
MSP_DECAY1/SDO/RSVD/EN2: J8.3 U1.66(P8.6/UCB1SOMI/UCB1SCL)
MSP_DIR/IN2/PH2: J8.11 U1.52(P4.2/TB0.2)
MSP_ENABLE/IN1/PH1: J8.13 U1.51(P4.1/TB0.1)
MSP_IPROPI1/IPROPI2: C10.2 R41.1 U1.98(P6.1/CB1/A1)
MSP_IPROPI2/IPROPI3: C9.2 R40.1 U1.99(P6.2/CB2/A2)
MSP_M0/nSCS/VREF1/EN4: J4.15 R54.2 TP15.1 U1.3(P6.6/CB6/A6/DAC0)
MSP_M1/SCLK/IN4/PH4: J8.7 R3.1 U1.54(P4.4/TB0.4) U1.62(P8.4/UCB1CLK/UCA1STE)
MSP_M1_PD: R3.2 U1.50(P4.0/TB0.0)
MSP_MODE2/IPROPI4: C8.2 R39.1 U1.100(P6.3/CB3/A3)
MSP_MODE/MODE1: J4.5 U1.67(P8.7)
MSP_nFAULT: J4.1 U1.24(P2.7/P2MAP7)
MSP_nHOME/OCPM: J4.3 U1.38(P1.4/TA0.3)
MSP_nSCS: R54.1 U1.59(P8.1/UCB1STE/UCA1CLK)
MSP_nSLEEP: J8.15 U1.41(P1.7/TA0.2)
MSP_RSVD/IPROPI1: C11.2 R42.1 U1.97(P6.0/CB0/A0)
MSP_STEP/IN3/PH3: J8.9 U1.53(P4.3/TB0.3)
MSP_TOFF/RSVD/EN3: J8.1 R2.1 U1.22(P2.5/P2MAP5)
MSP_TOFF_PD: R2.2 U1.23(P2.6/P2MAP6)
MSP_VREF/VREF2: J6.2 TP17.1 U1.4(P6.7/CB7/A7/DAC1)
nFAULT: J4.2 R6.1
nHOME/OCPM: J4.4 R9.1
nSCS/M0/EN4/VREF1/VREF: J25.1 J26.1 R23.1
nSLEEP: J8.16 R34.1
RST/SBWTDIO: C74.1 J3.11 R29.2 U1.96(~{RST}/NMI/SBWTDIO)
RSVD/IPROPI1: J4.14 R21.1
RSVD/IPROPI2/IPROPI1/IPROPI: J4.12 R18.1
RSVD/IPROPI3/IPROPI2/IPROPI: J4.10 R17.1
RSVD/TOFF/EN3: J8.2 R24.1
SCLK/M1/IN4/RSVD: J8.8 R27.1
SDI/DECAY0/EN1/DECAY: J8.6 R26.1
SDO/DECAY1/EN2/RSVD: J8.4 R25.1
STEP/IN3/RSVD: J8.10 R30.1
TB0CLK: U1.43(P3.1/TA1.0) U1.58(P8.0/TB0CLK)
TCK: J3.7 U1.95(PJ.3/TCK)
TDI: J3.3 U1.93(PJ.1/TDI/TCLK)
TDO: J3.1 U1.92(PJ.0/TDO)
TMS: J3.5 U1.94(PJ.2/TMS)
TST/SBWTCK: J3.8 U1.91(TEST/SBWTCK)
VREF/VREF2: J5.1 J6.1 J7.1 J25.2
VSEN_AOUT1: R5.1 R7.1
VSEN_AOUT2: R8.1 R10.1
VSEN_BOUT1: R12.1 R13.1
VSEN_BOUT2: R15.1 R16.1
VSEN_VM: J1.3 TP37.1 U1.1(P6.4/CB4/A4)
NetC1_1: C1.1 J1.10 TP40.1
NetC2_1: C2.1 J1.8 TP39.1
NetC7_2: C7.2 R4.2 U1.9(P5.0/VREF+/VEREF+)
NetC13_1: C13.1 U1.27(VCORE)
NetC15_2: C15.2 R35.2 U1.11(AVCC1)
NetC62_2: C62.2 J5.2 R19.2
NetC72_1: C72.1 U1.13(XIN) Y2.1
NetC73_2: C73.2 U1.14(XOUT) Y2.2
NetJ1_6: J1.6 TP38.1
NetJ2_4: J2.4 TP46.1
NetJ3_2: J3.2 R20.1
NetJ3_4: J3.4 R22.1
NetJ4_7: J4.7 R39.2
NetJ4_9: J4.9 R40.2
NetJ4_11: J4.11 R41.2
NetJ4_13: J4.13 R42.2
NetTP1_1: TP1.1 U1.17(P2.0/P2MAP0)
NetTP2_1: TP2.1 U1.18(P2.1/P2MAP1)
NetTP3_1: TP3.1 U1.19(P2.2/P2MAP2)
NetTP4_1: TP4.1 U1.20(P2.3/P2MAP3)
NetTP5_1: TP5.1 U1.21(P2.4/P2MAP4)
NetTP6_1: TP6.1 U1.42(P3.0/TA1CLK/CBOUT)
NetTP7_1: TP7.1 U1.44(P3.2/TA1.1)
NetTP8_1: TP8.1 U1.45(P3.3/TA1.2)
NetTP9_1: TP9.1 U1.46(P3.4/TA2CLK/SMCLK)
NetTP10_1: TP10.1 U1.55(P4.5/TB0.5)
NetTP11_1: TP11.1 U1.56(P4.6/TB0.6)
NetTP12_1: TP12.1 U1.57(P4.7/TB0OUTH/SVMOUT)
NetTP13_1: TP13.1 U1.2(P6.5/CB5/A5)
NetTP14_1: TP14.1 U1.16(P5.6/ADC12CLK/DMAE0)
NetTP16_1: TP16.1 U1.88(P5.7/RTCCLK)
NetTP18_1: TP18.1 U1.68(P9.0)
NetTP19_1: TP19.1 U1.69(P9.1)
NetTP20_1: TP20.1 U1.70(P9.2)
NetTP21_1: TP21.1 U1.71(P9.3)
NetTP22_1: TP22.1 U1.72(P9.4)
NetTP23_1: TP23.1 U1.73(P9.5)
NetTP24_1: TP24.1 U1.74(P9.6)
NetTP26_1: TP26.1 U1.75(P9.7)

Not connected (* = marked no-connect by the designer): J1 2* 5* 7* 11* 17* 19*; J2 6* 8* 9* 10* 11* 15* 16* 17* 19*; J3 6* 10* 12* 13* 14*; U1 28(P5.2) 30(DNC)* 47(P3.5/TA2.0) 48(P3.6/TA2.1) 49(P3.7/TA2.2) 77(PU.0) 78(NC)* 79(PU.1) 80(LDOI)* 81(LDOO)* 82(NC)* 86(VBAK)*

### Notes on the sheet
- MSP430F5338
- C2000 (LAUNCHXL-F280025C) connectors
- Bottom Layer
- (near J2) Bottom Layer
- DNP Pin 2 zero ohm resistor. If debug or programming adapter is used to power the MSP430, remove pin 4 resistor and populate pin 2 resistor.
- J25 and J26 are for 8262 single H-bridge mode.
  Connect J25, ties VREFs together. Disconnect J26, disconnects second VREF from MSP430.
- For selecting VREF signal.
  DEFAULT:
  Connect J6, pins 1 and 2

### Library data of the parts
A1-A4 TP13-TP17 TP37-TP46 = CMP-0055149-1: Test Point, Multipurpose, White, TH; Manufacturer: Keystone; CNHeader: FALSE; Green_Lifecycle: Active; Green_REACh: Passed; ContactFinish: Silver; CT: TRUE
C1-C6 = CMP-0006250-2: CAP, CERM, 33 pF, 50 V, +/- 5%, C0G/NP0, 0402; Manufacturer: TDK; Alternate Manufacturer: Wurth Electronics; Alternate PartNumber: 885012005058; TaMin_C: -55°C; Polarized: N; SizeAreaWB_mm2: 3; Value1: Unknown; U/M: EA; Value: 33pF; TaMax_C: 125°C; SizeZ_mm: 0.6; SizeX_mm: 1; SizeY_mm: 0.5; AEC Category: Q200
C7-C12 C15 C62 = CMP-0006221-1: CAP, CERM, 0.1 uF, 10 V, +/- 20%, X5R, 0402; Manufacturer: Wurth Elektronik; Value: 0.1uF; Polarized: N; U/M: EA; Cap_F: 100nF; Value1: Unknown; VDC_V: 10V; TaMin_C: -55°C; TaMax_C: 85°C; Cap_Case: 0402; AEC Category: Q200; SizeArea_mm2: 0.5; SizeAreaWB_mm2: 3; SizeX_mm: 1; SizeZ_mm: 0.6
C13 = CMP-0097299-1: 0.47 µF ±20% 10V Ceramic Capacitor X5R 0603 (1608 Metric); Manufacturer: Wurth Electronics; Value: 470nF; AEC Qualified: No; TempCo: 15%; SizeZ_mm: 0.87mm
C14 = CMP-0084376-1: CAP, Tantalum Polymer, 10 µF, 10 V,+/- 20%, 0.08 ohm, 3216-18 SMD; Manufacturer: Kemet; TaMin_C: -55°C; SizeArea_mm2: 5.12; Value: 10uF; SizeAreaWB_mm2: 10.92; SizeY_mm: 1.6; Polarized: Y; SizeX_mm: 3.2; AEC Qualified: N; TaMax_C: 105°C; SizeZ_mm: 1.8; ESR_ohm: 0.08; CompType: Capacitor; AEC Category: Q200
C16-C18 = CMP-0006221-2: CAP, CERM, 0.1 uF, 10 V, +/- 20%, X5R, 0402; Manufacturer: Wurth Elektronik; TaMin_C: -55°C; Polarized: N; SizeAreaWB_mm2: 3; Value1: Unknown; U/M: EA; Value: 0.1uF; TaMax_C: 85°C; SizeZ_mm: 0.6; SizeX_mm: 1; SizeY_mm: 0.5; Cap_F: 100nF; AEC Category: Q200
C19 = CMP-0097306-1: 33 pF ±5% 50V Ceramic Capacitor C0G, NP0 0402 (1005 Metric); Manufacturer: Wurth Electronics; AEC Qualified: No; Value: 33pF; TempCo: 30ppm/°C; SizeZ_mm: 0.55mm
C72 C73 = CMP-0006227-2: CAP, CERM, 0.01 uF, 16 V, +/- 10%, X7R, 0402; Manufacturer: Wurth Elektronik; TaMin_C: -55°C; Polarized: N; SizeAreaWB_mm2: 3; Value1: Unknown; U/M: EA; Value: 0.01uF; TaMax_C: 125°C; SizeZ_mm: 0.6; SizeX_mm: 1; SizeY_mm: 0.5; Cap_F: 10nF; AEC Category: Q200
C74 = CMP-1036-03017-2: CAP CER 1100PF 50V NP0 0805; Manufacturer: KEMET; Manufacturer Part Number: C0805C112F5GACTU; PartNumber: C0805C112F5GAC7800; Value: 1,100 pF; Tolerance: 0.01; Material: Ceramic; Temperature Characteristic: C0G; Temperature Coefficient: 30ppm/°C
J1 J2 = CMP-0075613-1: Receptacle, 2.54mm, 10x2, Gold, TH; PartNumber: SSQ-110-03-G-D; Manufacturer: Samtec; CompType: Socket Strip; Pitch_mm: 2.54; Gender: Female; Row_Count: 2; Current_A: 6.3A; Voltage_V: 550V; Cert_CSA: Y; Cert_CULUS: N; CT: True; CNHeader: False
J3 = CMP-0086014-1: Header, 2.54mm, 7x2, Gold, TH; Manufacturer: Wurth Elektronik; Pitch_mm: 2.54; Voltage_V: 250V; Shrouded: N; Gender: Male; Current_A: 3A; Cert_UL: Y; Row_Count: 2
J4 J8 = CMP-0075595-1: Header, 2.54mm, 8x2, Gold, SMT; Manufacturer: Samtec; Pitch_mm: 2.54; Gender: Male; Cert_CSA: Y; Current_A: 4.9A; Voltage_V: 475V; CT: False; Shrouded: N; Row_Count: 2; CNHeader: True
J5-J7 J25 J26 = CMP-0054566-1: Header, 100mil, 2x1, Gold, TH; Manufacturer: Sullins Connector Solutions; Alternate Manufacturer: Wurth Electronics; Alternate PartNumber: 61300211121; CNHeader: TRUE; Current_A: 3A; Green_Lifecycle: Active; Shrouded: N; Gender: Male; Green_REACh: Passed; Voltage_V: 1.8kV; Row_Count: 1; Pitch_mm: 2.54; CT: FALSE; Cert_UL: Y
R1 R5-R18 R20-R27 R30 R32-R34 R54 = CMP-0026992-3: RES, 0, 5%, 0.1 W, AEC-Q200 Grade 0, 0402; Manufacturer: Panasonic; PartNumber: ERJ-2GE0R00X; Value_Code: 0000; Power_W: 100mW; Value2: 0.1W; VDC_V: 50V; TempCo: 600 ppm/C; EIA_Code: E24; AEC Category: Q200; AEC Qualified: Y; SizeArea_mm2: 0.5; SizeAreaWB_mm2: 3; SizeX_mm: 1; SizeZ_mm: 0.6
R2 R3 = CMP-0025784-3: RES, 330 k, 5%, 0.1 W, 0603; Manufacturer: Vishay-Dale; Power_W: 100mW; TempCo: 200 ppm/C; U/M: EA; Value: 330k; EIA_Code: E24; SizeX_mm: 1.6; SizeY_mm: 0.8; SizeZ_mm: 1; Value2: 0.1W; SizeArea_mm2: 1.28; VDC_V: 75V; AEC Category: Q200
R4 R35 = CMP-0091848-1: 10 Ohms ±5% 0.05W, 1/20W Chip Resistor 0402 (1005 Metric) RF, High Frequency Thin Film; Manufacturer: Vishay; SizeZ_mm: 0.627mm; VDC_V: 37V; TempCo: 100ppm/°C; Power_W: 50mW; AEC Qualified: No; Value: 10
R19 R44 R49 = CMP-0021998-3: RES, 10.0 k, 1%, 0.1 W, 0603; Manufacturer: Vishay-Dale; Power_W: 100mW; TempCo: 100 ppm/C; Value_Code: 10k0; U/M: EA; Value: 10.0k; EIA_Code: E96; Res_ohm: 10k; SizeX_mm: 1.6; SizeY_mm: 0.8; SizeZ_mm: 1; Value2: 0.1W; SizeArea_mm2: 1.28; VDC_V: 75V; AEC Category: Q200
R29 = CMP-0026935-3: RES, 47 k, 5%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 200 ppm/C; Value_Code: 47k0; Value: 47k; EIA_Code: E24; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; AEC Qualified: Y; VDC_V: 50V; AEC Category: Q200; AEC Grade: 0
R39-R42 = CMP-0026071-2: RES, 1.00 k, 1%, 0.063 W, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 100 ppm/C; Value_Code: 1k00; U/M: EA; Value: 1.00k; EIA_Code: E96; Res_ohm: 1k; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; VDC_V: 50V; AEC Category: Q200
SH-J1-SH-J17 SH-J30 SH-J31 = CMP-0003761-2: Shunt, 2.54mm, Gold, Black; Manufacturer: Wurth Elektronik
TP1-TP12 TP18-TP24 TP26 = CMP-0003719-1: Testpoint; Manufacturer: Texas Instruments; CompType: Pad
TP25 = CMP-0055148-1: Test Point, Multipurpose, Black, TH; Manufacturer: Keystone; CNHeader: FALSE; Green_Lifecycle: Active; Green_REACh: Passed; ContactFinish: Silver; CT: TRUE
TP27 = CMP-0055147-1: Test Point, Multipurpose, Red, TH; Manufacturer: Keystone; CNHeader: FALSE; Green_Lifecycle: Active; Green_REACh: Passed; ContactFinish: Silver; CT: TRUE
U1 = CMP-0038879-1: 20 MHz Mixed Signal Microcontroller with 256 KB Flash, 18432 B SRAM and 74 GPIOs, -40 to 85 degC, 100-pin QFP (PZ), Green (RoHS & no Sb/Br); Manufacturer: Texas Instruments; Flash(KB): 256; USCI_B (I2C & SPI): 2; ADC Channels: 16; Comparators: Yes; Frequency(MHz): 20; DMA: 3; SRAM(B): 18432; Multiplier: 32x32; GPIO: 74; Timers - 16-bit: 4; SubFamily: 5 Series; ADC: 12-bit SAR
Y2 = CMP-0004566-4: Crystal, 32.768 kHz, 12.5pF, SMD; Manufacturer: Micro Crystal AG; TaMin_C: -40°C; TaMax_C: 85°C; AEC Category: Q200; AEC Qualified: N; Frequency Tolerance: 20 ppm

## Sheet MD040_Hardware_RevA.SchDoc
size 431 x 279 mm; Date: Not shown in title block; ApprovedBy: Not shown in title block; CheckedBy: Not shown in title block; Author: Not shown in title block; CompanyName: Not shown in title block; DrawnBy: ak; Engineer: Not shown in title block; Organization: Not shown in title block; Address1: Not shown in title block; Address2: Not shown in title block; Address3: Not shown in title block; Address4: Not shown in title block; DocumentNumber: 3; Revision: Use project parameter SCH_Rev; SheetNumber: 2; SheetTotal: 2; PageSetup: Record=PageOptions¦CenterHorizontal=True¦CenterVertical=True¦PrintScale=1.00¦XCorrection=1.00¦YCorrection=1.00¦PrintKind=0¦BorderSize=5000000¦LeftOffset=0¦BottomOffset=0¦Orientation=2¦PaperLength=1000¦PaperWidth=1000¦Scale=100¦PaperSource=15¦PrintQuality=600¦MediaType=1¦DitherType=10¦PaperKind=Letter¦PrintScaleMode=1

### Parts
!PCB1  Printed Circuit Board  (value not drawn)  (mechanical)
FID1  Fiducial  [Fiducial10-20]  (value not drawn)
FID2  Fiducial  [Fiducial10-20]  (value not drawn)
FID3  Fiducial  [Fiducial10-20]  (value not drawn)
H1  4822  [KEYSTONE_4822]
H1_Nut  9605  [Keystone_9605]
H2  4822  [KEYSTONE_4822]
H2_Nut  9605  [Keystone_9605]
H3  4822  [KEYSTONE_4822]
H3_Nut  9605  [Keystone_9605]
H4  4822  [KEYSTONE_4822]
H4_Nut  9605  [Keystone_9605]
LBL1  THT-14-423-10  Note: Size: 0.65" x 0.20 "  [Label_650x200]
LOGO1  CAUTION HOT SURFACE  [IEC_HotSurface_Small]  (no BOM)
Logo2  CE Mark  [CE_Mark_5mm]  (no BOM)
Logo3  Texas Instruments  [TI_Stacked_Overlay_Small]  (no BOM)
Logo4  FCC disclaimer  [FCC_disclaimer]  (no BOM)
Logo5  WEEE logo  [WEEE_Minimum]  (no BOM)
Logo6  CAUTION.  READ USER GUIDE BEFORE USE  [IEC_Caution_Small]  (no BOM)
LOGO7  CAUTION HOT SURFACE  [IEC_HotSurface_Small]  (no BOM)
ZZ1  This Assembly Note is for PCB labels only  [AssemblyNoteLabel]  (no BOM)
ZZ2  These assemblies are ESD sensitive, ESD precautions shall be observed.  [AssemblyNote]  (no BOM)
ZZ3  These assemblies must be clean and free from flux and all contaminants. Use of no clean flux is not acceptable.  [AssemblyNote]  (no BOM)
ZZ4  These assemblies must comply with workmanship standards IPC-A-610 Class 2, unless otherwise specified.  [AssemblyNote]  (no BOM)

### Notes on the sheet
- Variant
- Variant/Label Table
- Label Text
- 001
- 002
- DRV8452EVM
- DRV8462EVM
- 003
- 004
- 005
- DRV8952EVM
- DRV8962EVM
- DRV8252EVM
- 006
- 007
- DRV8262EVM
- DRV8461EVM

### Library data of the parts
!PCB1 = CMP-0003618-2: Manufacturer: Any; PartNumber: MD040
FID1-FID3 = CMP-0077181-1: Fiducial mark.  There is nothing to buy or mount.
H1-H4 = CMP-0003678-1: Standoff, Hex, 1.25"L #6-32 Nylon; Manufacturer: Keystone
H1_Nut H2_Nut H3_Nut H4_Nut = CMP-0003948-1: Small nylon hex nut, 0.10 thick with a 0.250 outside diameter and a 4-40 threading; Manufacturer: Keystone; CompType: Standoff
LBL1 = CMP-0003625-1: Thermal Transfer Printable Labels, 0.650" W x 0.200" H - 10,000 per roll; Manufacturer: Brady; CompType: Label
LOGO1 LOGO7 = CMP-0074837-1: IEC 61010-1 Hot Surface Warning; SymbolCreator: a0412235
Logo2 = CMP-0074844-1: SymbolCreator: a0412235
Logo3 = CMP-0074838-1: Texas Instrument Corporate Signature; SymbolCreator: a0412235; Lib Reference: TI_Logo; Library Reference: Logo
Logo4 = CMP-0074847-1: FCC_disclaimer; Library Reference: Logo
Logo5 = CMP-0074769-1
Logo6 = CMP-0074836-1: IEC 61010-1 Caution Warning; SymbolCreator: a0412235; Lib Reference: IEC_Caution
ZZ1 = CMP-0003616-3
ZZ2 = CMP-0077236-1
ZZ3 = CMP-0077237-1
ZZ4 = CMP-0077238-1

## Nets that join several sheets
GND: MD040_ezFET_RevA (59 pins), MD040_Motor_Driver_RevA (59 pins), MD040_Motor_control_RevA (38 pins)
MCU_3V3: MD040_ezFET_RevA (J10.10), MD040_Motor_Driver_RevA (11 pins), MD040_Motor_control_RevA (17 pins)
VM: MD040_ezFET_RevA (C44.1 U5.10), MD040_Motor_Driver_RevA (18 pins)
ACCEL/DECEL: MD040_Motor_Driver_RevA (D10.2), MD040_Motor_control_RevA (U1.37)
DIR/IN2: MD040_Motor_Driver_RevA (U7.40), MD040_Motor_control_RevA (J8.12 R32.1)
DRV_ENABLE: MD040_Motor_Driver_RevA (D9.2), MD040_Motor_control_RevA (U1.36)
ENABLE/IN1: MD040_Motor_Driver_RevA (U7.41), MD040_Motor_control_RevA (J8.14 R33.1)
EVM_STATUS: MD040_Motor_Driver_RevA (D6.2), MD040_Motor_control_RevA (U1.34)
FAULT: MD040_Motor_Driver_RevA (D12.2), MD040_Motor_control_RevA (U1.40)
GUI_STATUS: MD040_Motor_Driver_RevA (D8.2), MD040_Motor_control_RevA (U1.35)
ID1: MD040_Motor_Driver_RevA (R99.2 R105.1), MD040_Motor_control_RevA (U1.33)
ID2: MD040_Motor_Driver_RevA (R100.2 R106.1), MD040_Motor_control_RevA (U1.32)
ID3: MD040_Motor_Driver_RevA (R101.2 R107.1), MD040_Motor_control_RevA (U1.31)
ID4: MD040_Motor_Driver_RevA (R102.2 R108.1), MD040_Motor_control_RevA (U1.84)
ID5: MD040_Motor_Driver_RevA (R103.2 R109.1), MD040_Motor_control_RevA (U1.85)
INDEXER HOME: MD040_Motor_Driver_RevA (D11.2), MD040_Motor_control_RevA (U1.39)
MCU_UARTRXD: MD040_ezFET_RevA (J10.8), MD040_Motor_control_RevA (U1.61)
MCU_UARTTXD: MD040_ezFET_RevA (J10.6), MD040_Motor_control_RevA (U1.60)
MODE2/IPROPI4: MD040_Motor_Driver_RevA (J16.2 R79.2 U7.29), MD040_Motor_control_RevA (J4.8 R14.1)
MODE/MODE1: MD040_Motor_Driver_RevA (U7.28), MD040_Motor_control_RevA (J4.6 R11.1)
nFAULT: MD040_Motor_Driver_RevA (R83.1 R112.1 U7.26), MD040_Motor_control_RevA (J4.2 R6.1)
nHOME/OCPM: MD040_Motor_Driver_RevA (R88.1 U7.27), MD040_Motor_control_RevA (J4.4 R9.1)
nSCS/M0/EN4/VREF1/VREF: MD040_Motor_Driver_RevA (U7.34), MD040_Motor_control_RevA (J25.1 J26.1 R23.1)
nSLEEP: MD040_Motor_Driver_RevA (U7.42), MD040_Motor_control_RevA (J8.16 R34.1)
RST/SBWTDIO: MD040_ezFET_RevA (J10.4), MD040_Motor_Driver_RevA (J27.1), MD040_Motor_control_RevA (C74.1 J3.11 R29.2 U1.96)
RSVD/IPROPI1: MD040_Motor_Driver_RevA (J17.2 R80.2 U7.32), MD040_Motor_control_RevA (J4.14 R21.1)
RSVD/IPROPI2/IPROPI1/IPROPI: MD040_Motor_Driver_RevA (J18.2 J19.2 R81.2 U7.31), MD040_Motor_control_RevA (J4.12 R18.1)
RSVD/IPROPI3/IPROPI2/IPROPI: MD040_Motor_Driver_RevA (J19.1 J20.2 R82.2 U7.30), MD040_Motor_control_RevA (J4.10 R17.1)
RSVD/TOFF/EN3: MD040_Motor_Driver_RevA (U7.35), MD040_Motor_control_RevA (J8.2 R24.1)
SCLK/M1/IN4/RSVD: MD040_Motor_Driver_RevA (U7.38), MD040_Motor_control_RevA (J8.8 R27.1)
SDI/DECAY0/EN1/DECAY: MD040_Motor_Driver_RevA (U7.37), MD040_Motor_control_RevA (J8.6 R26.1)
SDO/DECAY1/EN2/RSVD: MD040_Motor_Driver_RevA (U7.36), MD040_Motor_control_RevA (J8.4 R25.1)
STEP/IN3/RSVD: MD040_Motor_Driver_RevA (U7.39), MD040_Motor_control_RevA (J8.10 R30.1)
TST/SBWTCK: MD040_ezFET_RevA (J10.2), MD040_Motor_control_RevA (J3.8 U1.91)
VREF/VREF2: MD040_Motor_Driver_RevA (U7.33), MD040_Motor_control_RevA (J5.1 J6.1 J7.1 J25.2)
VSEN_AOUT1: MD040_Motor_Driver_RevA (C67.1 R89.1 R93.2), MD040_Motor_control_RevA (R5.1 R7.1)
VSEN_AOUT2: MD040_Motor_Driver_RevA (C68.1 R90.1 R94.2), MD040_Motor_control_RevA (R8.1 R10.1)
VSEN_BOUT1: MD040_Motor_Driver_RevA (C69.1 R91.1 R95.2), MD040_Motor_control_RevA (R12.1 R13.1)
VSEN_BOUT2: MD040_Motor_Driver_RevA (C70.1 R92.1 R96.2), MD040_Motor_control_RevA (R15.1 R16.1)
VSEN_VM: MD040_Motor_Driver_RevA (C71.1 R98.1 R104.2), MD040_Motor_control_RevA (J1.3 TP37.1 U1.1)

## Assembly variants
001: not fitted A1 A2 A4 C1 C2 C3 C4 C5 C6 C41 C44 C45 C46 C72 C73 J1 J2 J3 J22 J24 R1 R6 R7 R9 R10 R11 R12 R14 R15 R17 R18 R21 R22 R23 R24 R25 R26 R27 R30 R32 R33 R34 R54 R62 R69 R70 R71 R73 R74 R101 R105 R106 R108 R109 TP13 TP15 TP16 TP37 TP38 TP39 TP40 TP41 TP42 TP43 TP44 TP45 TP46 U4 U5 Y2; alternate parts U7 -> CMP-0093481-2
002: not fitted A1 A2 A4 C1 C2 C3 C4 C5 C6 C41 C44 C45 C46 C72 C73 J1 J2 J3 J16 J17 J18 J19 J20 J22 J23 J24 R1 R6 R7 R9 R10 R11 R12 R14 R15 R17 R18 R21 R22 R23 R24 R25 R26 R27 R30 R32 R33 R34 R54 R62 R69 R70 R71 R73 R74 R79 R80 R81 R82 R84 R85 R86 R87 R102 R105 R106 R107 R109 TP13 TP15 TP16 TP37 TP38 TP39 TP40 TP41 TP42 TP43 TP44 TP45 TP46 U4 U5 Y2; alternate parts U7 -> CMP-0094066-1
003: not fitted A1 A2 A3 A4 C1 C2 C3 C4 C5 C6 C41 C44 C45 C46 C72 C73 J1 J2 J3 J22 J24 R1 R2 R3 R6 R7 R9 R10 R11 R12 R14 R15 R17 R18 R21 R22 R23 R24 R25 R26 R27 R30 R32 R33 R34 R54 R62 R69 R70 R71 R73 R74 R99 R100 R101 R108 R109 TP13 TP15 TP16 TP37 TP38 TP39 TP40 TP41 TP42 TP43 TP44 TP45 TP46 U4 U5 Y2; alternate parts U7 -> CMP-0094067-2
004: not fitted A1 A2 A3 A4 C1 C2 C3 C4 C5 C6 C41 C44 C45 C46 C72 C73 J1 J2 J3 J19 J22 J24 R1 R2 R3 R6 R7 R9 R10 R11 R12 R14 R15 R17 R18 R21 R22 R23 R24 R25 R26 R27 R30 R32 R33 R34 R54 R62 R69 R70 R71 R73 R74 R88 R99 R100 R102 R107 R109 TP13 TP15 TP16 TP37 TP38 TP39 TP40 TP41 TP42 TP43 TP44 TP45 TP46 U4 U5 Y2; alternate parts U7 -> CMP-0094068-2
005: not fitted A1 A2 A3 A4 C1 C2 C3 C4 C5 C6 C41 C44 C45 C46 C72 C73 J1 J2 J3 J22 J24 R1 R2 R3 R6 R7 R9 R10 R11 R12 R14 R15 R17 R18 R21 R22 R23 R24 R25 R26 R27 R30 R32 R33 R34 R54 R62 R69 R70 R71 R73 R74 R99 R101 R106 R108 R109 TP13 TP15 TP16 TP37 TP38 TP39 TP40 TP41 TP42 TP43 TP44 TP45 TP46 U4 U5 Y2; alternate parts U7 -> CMP-0094063-2
006: not fitted A1 A2 A3 A4 C1 C2 C3 C4 C5 C6 C41 C44 C45 C46 C72 C73 J1 J2 J3 J16 J17 J22 J23 J24 R1 R3 R6 R7 R9 R10 R11 R12 R14 R15 R17 R18 R21 R22 R23 R24 R25 R26 R27 R30 R32 R33 R34 R54 R62 R69 R70 R71 R73 R74 R79 R80 R84 R85 R88 R99 R102 R106 R107 R109 TP13 TP15 TP16 TP37 TP38 TP39 TP40 TP41 TP42 TP43 TP44 TP45 TP46 U4 U5 Y2; alternate parts U7 -> CMP-0094065-2
007: not fitted A1 A2 A4 C1 C2 C3 C4 C5 C6 C41 C44 C45 C46 C72 C73 J1 J2 J3 J16 J17 J18 J19 J20 J22 J23 J24 R1 R6 R7 R9 R10 R11 R12 R14 R15 R17 R18 R21 R22 R23 R24 R25 R26 R27 R30 R32 R33 R34 R54 R62 R69 R70 R71 R73 R74 R79 R80 R81 R82 R84 R85 R86 R87 R100 R101 R102 R105 R109 TP13 TP15 TP16 TP37 TP38 TP39 TP40 TP41 TP42 TP43 TP44 TP45 TP46 U4 U5 Y2; alternate parts U7 -> CMP-0096869-1