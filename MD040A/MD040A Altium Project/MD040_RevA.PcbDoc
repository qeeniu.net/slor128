# Altium PCB MD040_RevA.PcbDoc (part 2 of 5)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 5000 x 5000 mil, 4 copper layers (Top Layer, Signal Layer 1, Signal Layer 2, Bottom Layer), stack 61.2 mil thick; 336 components, 205 nets, 921 pads, 354 vias.
Unrouted connection lines stored in the file: 124.

## Design rules (kind name [scope] priority, off if disabled: settings) (continued)
PolygonConnect PolygonConnect_4 [All vs IsNamedPolygon('TOP_LAYER_VM_P046')] p91: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_3 [All vs IsNamedPolygon('TOP_LAYER_GND_P036') Or  IsNamedPolygon('TOP_LAYER_OUT2_P040') Or  IsNamedPolygon('TOP_LAYER_OUT1_P038')] p92: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_2 [InNet('EZFET_VBUS') vs IsNamedPolygon('TOP_LAYER_EZFET_VBUS_P008')] p93: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_1 [InNetClass('Power-Net') vs IsNamedPolygon('TOP_LAYER_EZFET_USB_SHIELD_P201')] p94: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect [All] p95: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
RoutingVias ThermalPadVias [IsVia and InAnyComponent] p1: holewidth=7.87 width=19.68 viastyle="Through Hole" minholewidth=7.87 minwidth=19.68 maxholewidth=12.99 maxwidth=23.62
RoutingVias [All] p2: holewidth=16 width=34 viastyle="Through Hole" minholewidth=7.87 minwidth=26 maxholewidth=40 maxwidth=65
SilkToBoardRegionClearance [Not ((IsComment or IsDesignator) And (Hide <> 'False')) and not InRegion(1000,500,4000,800)] p1:
SilkToSilkClearance SilkToSilkClearance_Pb-FreeLogo [(HasFootprint('Pb-Free_Overlay_Medium') OR HasFootprint('Pb-Free_Overlay_Small')) vs (HasFootprint('Pb-Free_Overlay_Medium') OR HasFootprint('Pb-Free_Overlay_Small'))] p1: silktosilkclearance=0
SilkToSilkClearance [All] p2: silktosilkclearance=3.94
SilkToSolderMaskClearance SilkToComponentPadClearance [(IsPad or IsFill or IsRegion) and InAnycomponent] p1: minsilkscreentomaskgap=5 clearancetoexposedcopper=TRUE
SilkToSolderMaskClearance "Silk to Solder Mask Opening" [All] p2: minsilkscreentomaskgap=3.94 clearancetoexposedcopper=FALSE
SolderMaskExpansion [All] p1: expansion=1.97 istentingtop=FALSE
UnRoutedNet [All] p1: checkbadconnections=TRUE
Width [All] p1: maxlimit=100 minlimit=6 preferedwidth=10 checkconnectedcopper=TRUE
14 further rules are at their usual default settings.

## Classes and differential pairs
component class MD040_Hardware_RevA: !PCB1 FID1 FID2 FID3 H1 H1_Nut H2 H2_Nut H3 H3_Nut H4 H4_Nut LBL1 LOGO1 Logo2 Logo3 Logo4 Logo5 Logo6 LOGO7 ZZ1 ZZ2 ZZ3 ZZ4
component class MD040_Motor_control_RevA: A1 A2 A3 A4 C1 C2 C3 C4 C5 C6 C7 C8 C9 C10 C11 C12 C13 C14 C15 C16 C17 C18 C19 C62 C72 C73 C74 J1 J2 J3 J4 J5 J6 J7 J8 J25 J26 R1 R2 R3 R4 R5 R6 R7 R8 R9 R10 R11 R12 R13 R14 R15 R16 R17 R18 R19 R20 R21 R22 R23 R24 R25 R26 R27 R29 R30 R32 R33 R34 R35 R39 R40 R41 R42 R44 R49 R54 SH-J1 SH-J2 SH-J3 SH-J4 SH-J5 SH-J6 SH-J7 SH-J8 SH-J9 SH-J10 SH-J11 SH-J12 SH-J13 SH-J14 SH-J15 SH-J16 SH-J17 SH-J30 SH-J31 TP1 TP2 TP3 TP4 TP5 TP6 TP7 TP8 TP9 TP10 TP11 TP12 TP13 TP14 TP15 TP16 TP17 TP18 TP19 TP20 TP21 TP22 TP23 TP24 TP25 TP26 TP27 TP37 TP38 TP39 TP40 TP41 TP42 TP43 TP44 TP45 TP46 U1 Y2
component class Shunt: SH-J1 SH-J2 SH-J3 SH-J4 SH-J5 SH-J6 SH-J7 SH-J8 SH-J9 SH-J10 SH-J11 SH-J12 SH-J13 SH-J14 SH-J15 SH-J16 SH-J17 SH-J18 SH-J19 SH-J20 SH-J21 SH-J22 SH-J23 SH-J24 SH-J25 SH-J26 SH-J27 SH-J28 SH-J29 SH-J30 SH-J31
component class MD040_Motor_Driver_RevA: C49 C50 C51 C52 C53 C54 C55 C56 C57 C58 C59 C60 C61 C63 C64 C65 C66 C67 C68 C69 C70 C71 D4 D5 D6 D8 D9 D10 D11 D12 D13 F1 J12 J13 J14 J15 J16 J17 J18 J19 J20 J21 J22 J23 J24 J27 J28 Q1 R79 R80 R81 R82 R83 R84 R85 R86 R87 R88 R89 R90 R91 R92 R93 R94 R95 R96 R97 R98 R99 R100 R101 R102 R103 R104 R105 R106 R107 R108 R109 R110 R111 R112 R113 R114 R115 R116 R117 R118 S1 SH-J18 SH-J19 SH-J20 SH-J21 SH-J22 TP28 TP29 TP30 TP31 TP32 TP34 TP35 TP36 U7
net class Power-Net: EZFET_VBUS EZFET_VCC GND MCU_3V3
component class Header: J3 J4 J5 J6 J7 J8 J9 J10 J16 J17 J18 J19 J20 J25 J26 J27
component class MD040_ezFET_RevA: C20 C21 C22 C23 C24 C25 C26 C27 C28 C29 C30 C31 C32 C33 C34 C35 C36 C37 C38 C39 C40 C41 C42 C43 C44 C45 C46 C47 C48 D1 D2 D3 J9 J10 J11 L1 L2 R55 R56 R57 R58 R59 R60 R61 R62 R63 R64 R65 R66 R67 R68 R69 R70 R71 R72 R73 R74 R75 R76 R77 R78 SH-J23 SH-J24 SH-J25 SH-J26 SH-J27 SH-J28 SH-J29 U2 U3 U4 U5 U6 Y1
component class Logo: Logo3
component class FiducialMark: FID1 FID2 FID3
component class AssemblyNote: ZZ1 ZZ2 ZZ3 ZZ4
component class Label: LBL1
differential pair USB_D: +USB_D_P -USB_D_N
differential pair EZFET_D: +EZFET_D_P -EZFET_D_N

## Components (designator, comment, footprint, x,y, rotation, side; value= is the part's Value field where it differs from the comment)
A1 "5012" Keystone5012 244.12,2581.6 r0 top
A2 "5012" Keystone5012 127.56,2455.33 r0 top
A3 "5012" Keystone5012 325.39,2301 r0 top
A4 "5012" Keystone5012 127.56,2163.78 r0 top
C1 "C1005C0G1H330J050BA" 0402 2643.95,309 r270 top value=33pF
C2 "C1005C0G1H330J050BA" 0402 2731,312 r270 top value=33pF
C3 "C1005C0G1H330J050BA" 0402 2704.47,615.26 r90 top value=33pF
C4 "C1005C0G1H330J050BA" 0402 2704.47,735.77 r90 top value=33pF
C5 "C1005C0G1H330J050BA" 0402 2704.47,853.88 r90 top value=33pF
C6 "C1005C0G1H330J050BA" 0402 2704.47,971.99 r90 top value=33pF
C7 "885012105010" 0402L 110,1758.56 r90 top value=0.1uF
C8 "885012105010" 0402L 650,2405 r270 top value=0.1uF
C9 "885012105010" 0402L 700,2402.94 r270 top value=0.1uF
C10 "885012105010" 0402L 750,2411.63 r270 top value=0.1uF
C11 "885012105010" 0402L 799.6,2452 r270 top value=0.1uF
C12 "885012105010" 0402L 1739,3413 r270 top value=0.1uF
C13 "885012106008" FP-885012106008_0603-MFG 608,1513 r0 top value=470nF
C14 "T520A106M010ATE080" 3216-18 1563.52,1933 r270 top value=10uF
C15 "885012105010" 0402L 537,1957 r90 top value=0.1uF
C16 "885012105010" 0402 490,1511 r0 top value=0.1uF
C17 "885012105010" 0402 1463.2,1929 r270 top value=0.1uF
C18 "885012105010" 0402 891,2366 r180 top value=0.1uF
C19 "885012005058" FP-885012005058_0402-MFG 2059,2609 r180 top value=33pF
C20 "C1005X5R1A475M050BC" 0402 1217.4,4156.75 r45 top value=4.7uF
C21 "885012105010" 0402 1371.3,3875.7 r315 top value=0.1uF
C22 "885012005058" FP-885012005058_0402-MFG 737,4365 r180 top value=33pF
C23 "885012205061" 0402 508,4519.78 r270 top value=1000pF
C24 "885012005058" FP-885012005058_0402-MFG 737,4513 r180 top value=33pF
C25 "885012105010" 0402 795.32,4231.57 r90 top value=0.1uF
C26 "885012005055" 0402 1314.68,3562 r180 top value=10pF
C27 "885012005055" 0402 1470.62,3306 r180 top value=10pF
C28 "885012105011" 0402 1154.85,4219.19 r45 top value=0.22uF
C29 "885012106008" FP-885012106008_0603-MFG 486.58,4153.89 r90 top value=470nF
C30 "885012105011" 0402 1186.31,4187.69 r45 top value=0.22uF
C31 "T520A106M010ATE080" 3216-18 579.08,4174.55 r90 top value=10uF
C32 "885012105010" 0402 741.58,4231.57 r90 top value=0.1uF
C33 "885012105010" 0402 679.13,4231.57 r90 top value=0.1uF
C34 "885012105010" 0402 1097.62,3728.76 r225 top value=0.1uF
C35 "885012105012" 0402 1238.67,4498.15 r90 top value=1uF
C36 "885012105010" 0402 1281.11,4498.17 r90 top value=0.1uF
C37 "885012205031" 0402 1325.15,4498.15 r90 top value=0.01uF
C38 "885012106018" 0603 1245.71,4387.83 r90 top value=2.2uF
C39 "885012205031" 0402 1342.71,4192.23 r0 top value=0.01uF
C40 "885012105012" 0402 1189.27,4409 r90 top value=1uF
C41 "885012105010" 0402L 2200,4306 r90 top value=0.1uF
C42 "885012005055" 0402 1450.9,4232.66 r180 top value=10pF
C43 "885012005055" 0402 1553.69,4232.66 r0 top value=10pF
C44 "HMK107BJ104MA-T" FP-0603-L_1_6_0_1-W_0_8_0-IPC_B 2062.63,3937.5 r270 top
C45 "885012105012" 0402 1563,3936.01 r270 top value=1uF
C46 "GRM21BC81E335KA73L" 0805_HV 1951.48,3878.94 r270 top value=3.3uF
C47 "885012105011" 0402 1786,4773.03 r0 top value=0.22uF
C48 "885012105010" 0402 1393.91,4488.31 r270 top value=0.1uF
C49 "C2012X7R1H105K125AB" 0805_HV 3631.46,2941.69 r90 top value=1uF
C50 "885012206120" FP-885012206120_0603-MFG 3627.8,2292.58 r90 top value=100nF
C51 "C2012X7R1H105K125AB" 0805_HV 4059.47,2208 r180 top value=1uF
C52 "885012006085" FP-885012006085_0603-MFG 4652,1758 r90 top value=1nF
C53 "EMVY101ARA101MKE0S" FP-EMVY101ARA101MKE0S_RADIAL-MFG 3629,3879.72 r180 top value=100µF
C54 "885012006085" FP-885012006085_0603-MFG 3066.15,4297.46 r180 bottom value=1nF
C55 "885012206120" FP-885012206120_0603-MFG 3063.49,4219.07 r180 bottom value=100nF
C56 "CGA6M2X7R2A105K200AA" 1210_220 4097,2099 r180 top value=1uF
C57 "885012206114" 0603L 4196.61,2575 r0 top value=0.01uF
C58 "885012206114" 0603L 4159.51,2285.44 r90 top value=0.01uF
C59 "885012206114" 0603L 4145.19,2873.57 r90 top value=0.01uF
C60 "885012006085" FP-885012006085_0603-MFG 4693.24,2192 r90 bottom value=1nF
C61 "885012006085" FP-885012006085_0603-MFG 4645,2575.07 r0 top value=1nF
C62 "885012105010" 0402L 2842.28,2521 r180 top value=0.1uF
C63 "885012206120" FP-885012206120_0603-MFG 3535.87,2928 r270 top value=100nF
C64 "885012006085" FP-885012006085_0603-MFG 4585,3630 r315 top value=1nF
C65 "885012006085" FP-885012006085_0603-MFG 4691,3227 r270 bottom value=1nF
C66 "885012006085" FP-885012006085_0603-MFG 4655,2679.86 r0 top value=1nF
C67 "885012005080" FP-885012005080_0402-MFG 4758,1471 r270 top value=100pF
C68 "885012005080" FP-885012005080_0402-MFG 4750,1156 r270 top value=100pF
C69 "885012005080" FP-885012005080_0402-MFG 4756,882.18 r270 top value=100pF
C70 "885012005080" FP-885012005080_0402-MFG 4757,578 r270 top value=100pF
C71 "885012005080" FP-885012005080_0402-MFG 4245.03,289.38 r270 top value=100pF
C72 "885012205031" 0402 429.66,2006.84 r0 top value=0.01uF
C73 "885012205031" 0402 430,2056 r180 top value=0.01uF
C74 "1.1 nF" FP-C0805C-DN-MFG 1458.81,2548.26 r180 top value="1,100 pF"
D1 "150060RS75000" WL-SMCW_RED 455.83,4325.87 r270 top value=Red
D2 "150060VS75000" WL-SMCW_GREEN 335.39,4330.24 r270 top value=Green
D3 "MMDL770T1G" ONSC-SOD-323-2-477-02_V 1368.83,4634 r180 top
D4 "150060VS75000" WL-SMCW_GREEN 3061.55,4602.39 r0 top value=Green
D5 "150060VS75000" WL-SMCW_GREEN 1657,3477 r90 top value=Green
D6 "150060VS75000" WL-SMCW_GREEN 230.07,1248.3 r90 top value=Green
D7 "SML-LX0603SIW-TR" FP-SML-LX0603SIW-TR_0603-MFG 5128,95 r0 top
D8 "150060VS75000" WL-SMCW_GREEN 349.92,1248.34 r90 top value=Green
D9 "150060YS75000" WL-SMCW_YELLOW 475.6,1248.75 r90 top value=Yellow
D10 "150060VS75000" WL-SMCW_GREEN 603,1247.5 r90 top value=Green
D11 "150060VS75000" WL-SMCW_GREEN 720.5,1249.5 r90 top value=Green
D12 "150060SS75000" WL-SMCW_RED 857,1250 r90 top value="Super Red"
D13 "BZX84J-B4V7,115" FP-BZX84J-B4V7,115_SC90-MFG 2717.06,4677.68 r180 top
F1 "0463015.ER" Fuse_0463 4238,3913 r90 top
FID1 "Fiducial" Fiducial10-20 78.74,4921.26 r0 top locked
FID2 "Fiducial" Fiducial10-20 78.74,78.74 r90 top
FID3 "Fiducial" Fiducial10-20 4921.26,4921.26 r0 top locked
H1 "4822" KEYSTONE_4822 255.91,255.91 r0 bottom locked
H1_Nut "9605" Keystone_9605 255.91,255.91 r0 top locked
H2 "4822" KEYSTONE_4822 4744.09,255.91 r0 bottom locked
H2_Nut "9605" Keystone_9605 4744.09,255.91 r0 top locked
H3 "4822" KEYSTONE_4822 4744.09,4744.09 r0 bottom locked
H3_Nut "9605" Keystone_9605 4744.09,4744.09 r0 top locked
H4 "4822" KEYSTONE_4822 255.91,4744.09 r180 bottom locked
H4_Nut "9605" Keystone_9605 255.91,4744.09 r0 top locked
J1 "CMP-0075613-1" Samtec_SSQ-110-03-x-D 2916.94,568.45 r90 bottom
J2 "CMP-0075613-1" Samtec_SSQ-110-03-x-D 1216.94,568.45 r90 bottom
J3 "61301421121" Wurth_61301421121 963,3071.26 r270 top
J4 "TSM-108-01-L-DV" Samtec_TSM-108-01-x-DV 2519.26,3246.98 r0 top
J5 "PBC02SAAN" Sullins_PBC02SAAN 2874,2703.25 r0 top
J6 "PBC02SAAN" Sullins_PBC02SAAN 2251,2753 r270 top
J7 "PBC02SAAN" Sullins_PBC02SAAN 2251,2613.02 r270 top
J8 "TSM-108-01-L-DV" Samtec_TSM-108-01-x-DV 2519.59,2095 r0 top
J9 "61301421121" Wurth_61301421121 846.43,4817.4 r270 top
J10 "61301421121" Wurth_61301421121 972,3385.02 r270 top
J11 "CMP-0055311-1" Molex_1051640001 1485.86,4938.27 r180 top
J12 "691256610002" FP-691256610002_HDR2-MFG 3915,4610.24 r180 top
J13 "691250610002" FP-691250610002_CONN_TERM_BLOCK2-MFG 4754.96,3210.19 r90 top
J14 "691250610002" FP-691250610002_CONN_TERM_BLOCK2-MFG 4754.78,2179.47 r90 top
J15 "D3082-05" Harwin_D3082-05 2793.72,4842.43 r180 top
J16 "PBC02SAAN" Sullins_PBC02SAAN 3068,3278.58 r90 top
J17 "PBC02SAAN" Sullins_PBC02SAAN 3086,2700.59 r90 top
J18 "PBC02SAAN" Sullins_PBC02SAAN 3090.12,2843.7 r90 top
J19 "PBC02SAAN" Sullins_PBC02SAAN 3283.79,2944.54 r0 top
J20 "PBC02SAAN" Sullins_PBC02SAAN 3091,3118 r90 top
J21 "D3082-05" Harwin_D3082-05 139,3707 r90 top
J22 "D3082-05" Harwin_D3082-05 4295.44,2544.74 r270 top
J23 "691250610002" FP-691250610002_CONN_TERM_BLOCK2-MFG 4755,3989 r90 top
J24 "D3082-05" Harwin_D3082-05 4451,2583 r270 top
J25 "PBC02SAAN" Sullins_PBC02SAAN 2522.62,2753 r270 top
J26 "PBC02SAAN" Sullins_PBC02SAAN 2734,2702 r0 top
J27 "61300311121" WURTH_61300311121 1760,2602 r0 top
J28 "D3082-05" Harwin_D3082-05 4542,1439 r90 top
L1 "BLM18AG151BH1D" 0603 1256.1,4683.31 r270 top value="150 ohm"
L2 "BLM18AG151BH1D" 0603 1559.22,4627.72 r270 top value="150 ohm"
LBL1 "THT-14-423-10" Label_650x200 2571,3992 r0 top
LOGO1 "CAUTION HOT SURFACE" IEC_HotSurface_Small 3863,3058 r0 top
Logo2 "CE Mark" CE_Mark_5mm 2017,855.84 r180 bottom
Logo3 "Texas Instruments" TI_Stacked_Overlay_Small 3714,1305 r0 top
Logo4 "FCC disclaimer" FCC_disclaimer 8653,-1614.39 r90 bottom
Logo5 "WEEE logo" WEEE_Minimum 2036,528.08 r180 bottom
Logo6 "CAUTION.  READ USER GUIDE BEFORE USE" IEC_Caution_Small 2067.96,570.04 r0 top
LOGO7 "CAUTION HOT SURFACE" IEC_HotSurface_Small 3637,2600 r180 bottom
Q1 "BC846BLT1G" ONSC-SOT-23-3-318-08_V 2904.07,4627.5 r0 top
R1 "Resistor" 0402L 3096.08,115.69 r180 top value=0
R2 "CRCW0603330KJNEA" 0603L 513.67,1689.83 r270 top value=330k
R3 "CRCW0603330KJNEA" 0603L 1317.1,1570.18 r180 top value=330k
R4 "CH0402-10RJFPT" FP-CH0402-10RJFPT_0402-MFG 127.47,1856.48 r180 top value=10
R5 "Resistor" 0402L 4663,1471 r270 top value=0
R6 "Resistor" 0402L 3094.11,821.4 r180 top value=0
R7 "Resistor" 0402L 4705,1471 r270 top value=0
R8 "Resistor" 0402L 4652,1156 r270 top value=0
R9 "Resistor" 0402L 1430.72,113.72 r180 top value=0
R10 "Resistor" 0402L 4696,1156 r270 top value=0
R11 "Resistor" 0402L 1430.72,718.45 r180 top value=0
R12 "Resistor" 0402L 4704,882.18 r270 top value=0
R13 "Resistor" 0402L 4665,882.18 r270 top value=0
R14 "Resistor" 0402L 2582.3,922.78 r0 top value=0
R15 "Resistor" 0402L 4704,578 r270 top value=0
R16 "Resistor" 0402L 4665,578 r270 top value=0
R17 "Resistor" 0402L 2582.3,823.65 r0 top value=0
R18 "Resistor" 0402L 2583.25,706.24 r0 top value=0
R19 "CRCW060310K0FKEA" 0603 2707.15,1102 r180 top value=10.0k
R20 "Resistor" 0402L 1265,2904 r180 top value=0
R21 "Resistor" 0402L 2582.3,590.26 r0 top value=0
R22 "Resistor" 0402L 1174,2902 r0 top value=0
R23 "Resistor" 0402L 1426,925 r180 top value=0
R24 "Resistor" 0402L 1431.69,218.45 r180 top value=0
R25 "Resistor" 0402L 1425,816 r180 top value=0
R26 "Resistor" 0402L 1425.69,613.3 r180 top value=0
R27 "Resistor" 0402L 3094.11,714.12 r180 top value=0
R29 "CRCW040247K0JNED" 0402 887.07,2462 r180 top value=47k
R30 "Resistor" 0402L 1428,1016 r180 top value=0
R32 "Resistor" 0402L 1430.72,316.48 r180 top value=0
R33 "Resistor" 0402L 3094.11,519.24 r180 top value=0
R34 "Resistor" 0402L 1430.72,420.81 r180 top value=0
R35 "CH0402-10RJFPT" FP-CH0402-10RJFPT_0402-MFG 230.55,1856.48 r0 top value=10
R39 "CRCW04021K00FKED" 0402L 2250,3299 r0 top value=1.00k
R40 "CRCW04021K00FKED" 0402L 2248.35,3196.98 r0 top value=1.00k
R41 "CRCW04021K00FKED" 0402L 2249.9,3097 r0 top value=1.00k
R42 "CRCW04021K00FKED" 0402L 2249.31,2996 r0 top value=1.00k
R44 "CRCW060310K0FKEA" 0603 2055.93,2760 r180 top value=10.0k
R49 "CRCW060310K0FKEA" 0603 2055.93,2680.83 r0 top value=10.0k
R54 "Resistor" 0402L 679.13,2815 r180 top value=0
R55 "RC0402FR-07220KL" 0402 738,4461 r180 top value=220k
R56 "240k" RESC1005X40X25NL05T05 736,4622 r180 top
R57 "CRCW040247K0JNED" 0402 572,4519 r270 top value=47k
R58 "CRCW0402470RJNED" 0402 417.14,4148.71 r270 top value=470
R59 "CRCW0402560RJNED" 0402 334.39,4150.93 r270 top value=560
R60 "RC0402FR-07220KL" 0402 738,4418 r0 top value=220k
R61 "CRCW0402150KFKED" 0402 738,4568 r0 top value=150k
R62 "ERJ-2GE0R00X" 0402L 1081.15,4574.22 r90 top value=0
R63 "ERJ-2GE0R00X" 0402L 1122.53,4574.22 r90 top value=0
R64 "CRCW040210R0FKED" 0402 1196.13,3587.09 r225 top value=10.0
R65 "CRCW040210R0FKED" 0402 1096.78,3587.09 r225 top value=10.0
R66 "CRCW040210R0FKED" 0402 997.7,3587.15 r225 top value=10.0
R67 "CRCW040210R0FKED" 0402 897.42,3587.09 r225 top value=10.0
R68 "Resistor" 0402L 1482.5,4061.04 r270 top value=0
R69 "Resistor" 0603L 1695.8,4569 r0 top value=0
R70 "Resistor" 0603L 1697.07,4463.9 r180 top value=0
R71 "CRCW040227R0JNED" 0402 1693.38,4163.18 r0 top value=27
R72 "CRCW040227R0JNED" 0402 1480.94,4426.57 r270 top value=27
R73 "CRCW040227R0JNED" 0402 1694,4226.15 r0 top value=27
R74 "0" RESC1005X40X25NL05T05 1464,3994.83 r180 top
R75 "CRCW040227R0JNED" 0402 1529.37,4426.57 r270 top value=27
R76 "CRCW04021K40FKED" 0402 1277.89,4042.33 r315 top value=1.40k
R77 "CRCW04021M00JNED" 0402 1306.35,4072.35 r135 top value=1.0Meg
R78 "CRCW040233K0JNED" 0402 1786,4836 r180 top value=33k
R79 "ERJ-2RKF3301X" 0402L 3094,3390 r0 top value=3.30k
R80 "ERJ-2RKF3301X" 0402L 3112,2585.99 r0 top value=3.30k
R81 "ERJ-2RKF3301X" 0402L 3124,2956.93 r0 top value=3.30k
R82 "ERJ-2RKF3301X" 0402L 3123.31,3003.4 r0 top value=3.30k
R83 "RC0603JR-0710KL" 0603L 3579,2794 r90 top value=10k
R84 "CRCW04020000Z0EDHP" 0402 3001,3391 r0 top value=0
R85 "CRCW04020000Z0EDHP" 0402 3022.23,2585.99 r0 top value=0
R86 "CRCW04020000Z0EDHP" 0402 3031,2956 r0 top value=0
R87 "CRCW04020000Z0EDHP" 0402 3032,3003.4 r0 top value=0
R88 "RC0603JR-0710KL" 0603L 3499,2793.22 r90 top value=10k
R89 "CRCW060386K6FKEA" 0603L 4817,1584.4 r90 top value=86.6k
R90 "CRCW060386K6FKEA" 0603L 4808.22,1298.49 r90 top value=86.6k
R91 "CRCW060386K6FKEA" 0603L 4818.48,1009.13 r90 top value=86.6k
R92 "CRCW060386K6FKEA" 0603L 4819.04,699 r90 top value=86.6k
R93 "CRCW06034K99FKEA" 0603L 4817,1471 r90 top value=4.99k
R94 "CRCW06034K99FKEA" 0603L 4809.14,1154.79 r90 top value=4.99k
R95 "CRCW06034K99FKEA" 0603L 4818.48,881.18 r90 top value=4.99k
R96 "CRCW06034K99FKEA" 0603L 4818,577 r90 top value=4.99k
R97 "CRCW040247K0JNED" 0402 3061.55,4668.92 r0 top value=47k
R98 "RT0603DRE0797K6L" 0603 4325,405.58 r90 top value=97.6k
R99 "RC0603JR-0710KL" 0603L 211,1343 r180 top value=10k
R100 "RC0603JR-0710KL" 0603L 211,1423 r180 top value=10k
R101 "RC0603JR-0710KL" 0603L 212,1511 r180 top value=10k
R102 "RC0603JR-0710KL" 0603L 1246.45,2550.6 r270 top value=10k
R103 "RC0603JR-0710KL" 0603L 1157,2550.56 r270 top value=10k
R104 "CRCW06034K99FKEA" 0603L 4325.24,292.18 r90 top value=4.99k
R105 "RC0603JR-0710KL" 0603L 97,1343 r180 top value=10k
R106 "RC0603JR-0710KL" 0603L 96,1421.84 r180 top value=10k
R107 "RC0603JR-0710KL" 0603L 98,1509 r180 top value=10k
R108 "RC0603JR-0710KL" 0603L 1246.45,2437.2 r270 top value=10k
R109 "RC0603JR-0710KL" 0603L 1157,2437.16 r270 top value=10k
R110 "RC0603FR-07560RL" 0603 1655.89,3341.12 r90 top value=560
R111 "CMP-0025785-4" 0603L 601.14,1117.82 r90 top value=330
R112 "CMP-0025785-4" 0603L 2963,3577 r0 top value=330
R113 "CMP-0025785-4" 0603L 349.92,1114 r90 top value=330
R114 "CMP-0025785-4" 0603L 229.56,1112 r90 top value=330
R115 "CMP-0025785-4" 0603L 475.7,1113.31 r90 top value=330
R116 "CMP-0025785-4" 0603L 721.19,1117.57 r90 top value=330
R117 "CMP-0025785-4" 0603L 853.92,1118.19 r90 top value=330
R118 "RC0603FR-07470RL" 0603 2706.12,4588.61 r0 top value=470
S1 "430481025816" FP-430481025816_SMT_SW_6MM2_6MM2-MFG 1878,2367 r0 top
SH-J1 "60900213421" Wurth_60900213421 2519.26,3596.98 r180 top
SH-J2 "60900213421" Wurth_60900213421 2519.26,3495.44 r180 top
SH-J3 "60900213421" Wurth_60900213421 871.6,3385.83 r90 top
SH-J4 "60900213421" Wurth_60900213421 2519.26,3393.9 r180 top
SH-J5 "60900213421" Wurth_60900213421 5098,1707 r90 top
SH-J6 "60900213421" Wurth_60900213421 971.2,3385.83 r90 top
SH-J7 "60900213421" Wurth_60900213421 2519.26,3292.35 r180 top
SH-J8 "60900213421" Wurth_60900213421 2519.26,2429.62 r0 top
SH-J9 "60900213421" Wurth_60900213421 1070.8,3385.83 r90 top
SH-J10 "60900213421" Wurth_60900213421 2519.26,3190.81 r180 top
SH-J11 "60900213421" Wurth_60900213421 2519.26,2987.72 r180 top
SH-J12 "60900213421" Wurth_60900213421 1270,3385.83 r90 top
SH-J13 "60900213421" Wurth_60900213421 2519.26,3089.26 r180 top
SH-J14 "60900213421" Wurth_60900213421 2519.26,2886.18 r180 top
SH-J15 "60900213421" Wurth_60900213421 1170.4,3385.83 r90 top
SH-J16 "60900213421" Wurth_60900213421 2519.26,2331.71 r0 top
SH-J17 "60900213421" Wurth_60900213421 2519.26,2037.97 r0 top
SH-J18 "60900213421" Wurth_60900213421 2519.26,1744.24 r0 top
SH-J19 "60900213421" Wurth_60900213421 2519.26,2233.8 r0 top
SH-J20 "60900213421" Wurth_60900213421 2519.26,1940.06 r0 top
SH-J21 "60900213421" Wurth_60900213421 2519.26,1842.15 r0 top
SH-J22 "60900213421" Wurth_60900213421 2519.26,2135.89 r0 top
SH-J23 "60900213421" Wurth_60900213421 5814,142 r90 top
SH-J24 "60900213421" Wurth_60900213421 5098,375.33 r90 top
SH-J25 "60900213421" Wurth_60900213421 5098,641.67 r90 top
SH-J26 "60900213421" Wurth_60900213421 5098,908 r90 top
SH-J27 "60900213421" Wurth_60900213421 1711.69,2601.93 r180 top
SH-J28 "60900213421" Wurth_60900213421 2251,2753 r180 top
SH-J29 "60900213421" Wurth_60900213421 2734,2702 r90 top
SH-J30 "60900213421" Wurth_60900213421 5098,1440.67 r90 top
SH-J31 "60900213421" Wurth_60900213421 5098,1174.33 r90 top
TP1 "TP_H0.45P0.75" TP_H045P075 317.77,1761.28 r90 top
TP2 "TP_H0.45P0.75" TP_H045P075 388.67,1731.28 r90 top
TP3 "TP_H0.45P0.75" TP_H045P075 320.21,1683 r90 top
TP4 "TP_H0.45P0.75" TP_H045P075 390,1646 r90 top
TP5 "TP_H0.45P0.75" TP_H045P075 319.77,1604.33 r90 top
TP6 "TP_H0.45P0.75" TP_H045P075 1032.53,1520.65 r90 top
TP7 "TP_H0.45P0.75" TP_H045P075 1098,1456.19 r90 top
TP8 "TP_H0.45P0.75" TP_H045P075 1096,1519.67 r90 top
TP9 "TP_H0.45P0.75" TP_H045P075 1168,1518.68 r90 top
TP10 "TP_H0.45P0.75" TP_H045P075 1348.01,1793.61 r90 top
TP11 "TP_H0.45P0.75" TP_H045P075 1370.56,1858.57 r90 top
TP12 "TP_H0.45P0.75" TP_H045P075 1306.27,1862.13 r90 top
TP13 "5012" Keystone5012 564,2674 r0 top
TP14 "5012" Keystone5012 379,1883 r0 top
TP15 "5012" Keystone5012 358.01,2726.36 r0 top
TP16 "5012" Keystone5012 1017,2504.01 r0 top
TP17 "5012" Keystone5012 406.16,2578.12 r0 top
TP18 "TP_H0.45P0.75" TP_H045P075 1431.47,2041.58 r90 top
TP19 "TP_H0.45P0.75" TP_H045P075 1368,2061.53 r90 top
TP20 "TP_H0.45P0.75" TP_H045P075 1432,2105.05 r90 top
TP21 "TP_H0.45P0.75" TP_H045P075 1368,2125 r90 top
TP22 "TP_H0.45P0.75" TP_H045P075 1434,2168.53 r90 top
TP23 "TP_H0.45P0.75" TP_H045P075 1368,2200.29 r90 top
TP24 "TP_H0.45P0.75" TP_H045P075 1432,2232 r90 top
TP25 "5011" Keystone5011 91,1175 r0 top
TP26 "TP_H0.45P0.75" TP_H045P075 1366.71,2263.76 r90 top
TP27 "5010" Keystone5010 1656,3676 r0 top
TP28 "5010" Keystone5010 3298,3325 r0 top
TP29 "5011" Keystone5011 4499,4715 r0 top
TP30 "5010" Keystone5010 3178,3979.46 r180 top
TP31 "5015" Testpoint_Keystone_Miniature 4821.94,1777 r270 top
TP32 "5015" Testpoint_Keystone_Miniature 4824,2574.6 r90 top
TP34 "5015" Testpoint_Keystone_Miniature 4828,3597 r90 top
TP35 "5015" Testpoint_Keystone_Miniature 4822,2805 r90 top
TP36 "5010" Keystone5010 3294,4716 r0 top
TP37 "5012" Keystone5012 3510.44,341 r0 top
TP38 "5012" Keystone5012 3320.69,378 r0 top
TP39 "5012" Keystone5012 3510.44,521.5 r0 top
TP40 "5012" Keystone5012 3319.6,562 r0 top
TP41 "5012" Keystone5012 3506.81,701 r0 top
TP42 "5012" Keystone5012 3320.69,763 r0 top
TP43 "5012" Keystone5012 3507.9,879 r0 top
TP44 "5012" Keystone5012 3325,959 r0 top
TP45 "5012" Keystone5012 3509,1057 r0 top
TP46 "5012" Keystone5012 689,218 r0 top
U1 "MSP430F5338IPZ" PZT0100A_N 928.04,1942.9 r0 top
U2 "CMP-0039269-4" RGC0064B 919.92,4000.21 r315 top
U3 "TPS73533DRBR" DRB0008A 1380.69,4339.77 r90 top
U4 "FT232RL" SSOP28_N 1965.27,4399 r0 top
U5 "TPS7A4333DGQ" DGQ0010E-MFG 1763.66,3931.23 r0 top
U6 "TPD2E001DRYR" DRY0006A 1476.72,4670.58 r90 top
U7 "DRV8462DDWR" DDW0044E-MFG 3863.61,2573.33 r180 top
Y1 "CSTNR4M00GH5L000R0" MuRata_CSTNR 1095.47,4350.65 r135 top
Y2 "MS3V-T1R 32.768KHZ +/-20PPM 12.5PF" XTAL_MS3V-T1R 225.37,2028.41 r180 top
ZZ1 "This Assembly Note is for PCB labels only" AssemblyNoteLabel 196.85,5757.87 r0 top
ZZ2 "These assemblies are ESD sensitive, ESD precautions shall be observed." AssemblyNote 196.85,5639.76 r0 top
ZZ3 "These assemblies must be clean and free from flux and all contaminants. Use of no clean flux is not acceptable." AssemblyNote 196.85,5511.81 r0 top
ZZ4 "These assemblies must comply with workmanship standards IPC-A-610 Class 2, unless otherwise specified." AssemblyNote 196.85,5364.17 r0 top

## Footprints (in the part's own frame and the unit in brackets; to place one, negate y for a bottom-side part, rotate by r counter-clockwise, add the part's x,y. Pads: shape width x height; smd on the part's side, far side on the other; paste and mask are expansions set on the pad)
0402 [mm] "0402 from SM-752 data"
  rect 0.8x0.6 smd: 1(-0.6,0) 2(0.6,0)
  silkscreen extent -1.22,-0.52 1.22,0.52, body extent -0.55,-0.3 0.55,0.3, height 0.6
0402L [mm] "0402 from SM-752 data"
  rect 0.6x0.5 smd: 1(-0.5,0) 2(0.5,0)
  body extent -0.55,-0.3 0.55,0.3, height 0.6
0603 [mm] "0603 from SM-752 data"
  rect 1x0.95 smd: 1(-0.8,0) 2(0.8,0)
  silkscreen extent -1.52,-0.69 1.52,0.69, body extent -0.87,-0.47 0.87,0.47, height 1
0603L [mm] "0603 from SM-752 data"
  rect 0.8x0.85 smd: 1(-0.7,0) 2(0.7,0)
  silkscreen extent -0.07,-0.33 0.07,0.33, body extent -0.87,-0.47 0.87,0.47, height 1
0805_HV [mil] "0805 with 30mil clearance between pads"
  rect 50x63 smd: 1(-40,0) 2(40,0)
  silkscreen extent -74,-40 74,40, body extent -43,-29 43,29, height 57
1210_220 [mm] "1210"
  rect 1.3x2.7 smd: 1(-1.45,0) 2(1.45,0)
  silkscreen extent -2.32,-1.57 2.32,1.57, body extent -1.7,-1.35 1.7,1.35, height 2.2
3216-18 [mm] "Based on AVX recommendation in http://www.avx.com/download/software/literature/AVX-Footprint-Library.pdf"
  rrect7% 1.4x1.8 smd: 1(-1.3,0) 2(1.3,0)
  silkscreen extent -1.9,-1.12 0.8,1.12, body extent -1.7,-0.9 1.7,0.9, height 1.82
AssemblyNote [mil] "Assembly Note"
AssemblyNoteLabel [mil] "Assembly Note for PCB Labels"
CE_Mark_5mm [mil] "Minimum text height for CE Mark"
  silkscreen extent -138,-98 138,98
DDW0044E-MFG [mm]
  rrect25% 1.45x0.4 smd paste+0 mask+0: 1(-3.75,6.668) 2(-3.75,6.033) 3(-3.75,5.398) 4(-3.75,4.763) 5(-3.75,4.128) 6(-3.75,3.493) 7(-3.75,2.858) 8(-3.75,2.223) 9(-3.75,1.588) 10(-3.75,0.953) 11(-3.75,0.318) 12(-3.75,-0.318) 13(-3.75,-0.953) 14(-3.75,-1.588) 15(-3.75,-2.223) 16(-3.75,-2.858) 17(-3.75,-3.493) 18(-3.75,-4.128) 19(-3.75,-4.763) 20(-3.75,-5.398) 21(-3.75,-6.033) 22(-3.75,-6.667) 23(3.75,-6.667) 24(3.75,-6.032) 25(3.75,-5.397) 26(3.75,-4.762) 27(3.75,-4.127) 28(3.75,-3.492) 29(3.75,-2.857) 30(3.75,-2.222) 31(3.75,-1.587) 32(3.75,-0.952) 33(3.75,-0.317) 34(3.75,0.318) 35(3.75,0.953) 36(3.75,1.588) 37(3.75,2.223) 38(3.75,2.858) 39(3.75,3.493) 40(3.75,4.128) 41(3.75,4.763) 42(3.75,5.398) 43(3.75,6.033) 44(3.75,6.668)
  rrect2% 5.2x14 smd paste-1000 mask-1000: 45(0,0)
  silkscreen extent -5.16,-7.4 3.1,7.4, body extent -4.57,-7.3 4.57,7.3, height 0.25
DGQ0010E-MFG [mm]
  rrect33% 1.45x0.3 smd paste+0 mask+0: 1(-2.2,1) 2(-2.2,0.5) 3(-2.2,0) 4(-2.2,-0.5) 5(-2.2,-1) 6(2.2,-1) 7(2.2,-0.5) 8(2.2,0) 9(2.2,0.5) 10(2.2,1)
  rrect5% 2.2x3.1 smd paste-1000 mask-1000: 11(0,0)
  silkscreen extent -3.6,-1.65 1.65,1.65, body extent -3.03,-1.8 3.03,1.8, height 0.25
DRB0008A [mm] "VSON-8"
  rrect32% 0.6x0.31 smd: 1(-1.4,0.975) 2(-1.4,0.325) 3(-1.4,-0.325) 4(-1.4,-0.975) 5(1.4,-0.975) 6(1.4,-0.325) 7(1.4,0.325) 8(1.4,0.975)
  rrect7% 1.5x1.75 smd paste-0.75: 9(0,0)
  Top Layer region: -0.7,-0.875 -0.49,-0.875 -0.471,-0.879 -0.455,-0.89 -0.444,-0.906 -0.44,-0.925 -0.44,-0.925 -0.44,-1.65 -0.436,-1.669 -0.425,-1.685 -0.409,-1.696 -0.39,-1.7 -0.39,-1.7 -0.26,-1.7 -0.241,-1.696 -0.225,-1.685 -0.214,-1.669 -0.21,-1.65 -0.21,-1.65 -0.21,-0.925 -0.206,-0.906 -0.195,-0.89 -0.179,-0.879 -0.16,-0.875 -0.16,-0.875 0.16,-0.875 0.179,-0.879 0.195,-0.89 0.206,-0.906 0.21,-0.925 0.21,-0.925 0.21,-1.65 0.21,-1.65 0.214,-1.669 0.225,-1.685 0.241,-1.696 0.26,-1.7 0.26,-1.7 0.39,-1.7 0.409,-1.696 0.425,-1.685 0.436,-1.669 0.44,-1.65 0.44,-1.65 0.44,-0.925 0.444,-0.906 0.455,-0.89 0.471,-0.879 0.49,-0.875 0.49,-0.875 0.7,-0.875 0.719,-0.871 0.735,-0.86 0.746,-0.844 0.75,-0.825 0.75,-0.825 0.75,0.825 0.746,0.844 0.735,0.86 0.719,0.871 0.7,0.875 0.7,0.875 0.49,0.875 0.471,0.879 0.455,0.89 0.444,0.906 0.44,0.925 0.44,0.925 0.44,1.65 0.436,1.669 0.425,1.685 0.409,1.696 0.39,1.7 0.39,1.7 0.26,1.7 0.241,1.696 0.225,1.685 0.214,1.669 0.21,1.65 0.21,1.65 0.21,1.65 0.21,0.925 0.206,0.906 0.195,0.89 0.179,0.879 0.16,0.875 0.16,0.875 -0.16,0.875 -0.179,0.879 -0.195,0.89 -0.206,0.906 -0.21,0.925 -0.21,0.925 -0.21,1.65 -0.214,1.669 -0.225,1.685 -0.241,1.696 -0.26,1.7 -0.26,1.7 -0.39,1.7 -0.409,1.696 -0.425,1.685 -0.436,1.669 -0.44,1.65 -0.44,1.65 -0.44,0.925 -0.444,0.906 -0.455,0.89 -0.471,0.879 -0.49,0.875 -0.49,0.875 -0.7,0.875 -0.719,0.871 -0.735,0.86 -0.746,0.844 -0.75,0.825 -0.75,0.825 -0.75,-0.825 -0.746,-0.844 -0.735,-0.86 -0.719,-0.871 -0.7,-0.875
  silkscreen extent -1.73,-1.73 1.73,1.73, body extent -1.5,-1.5 1.5,1.5, height 0.77
DRY0006A [mm] "USON-6"
  rrect67% 0.45x0.3 smd paste-0.05 mask-0.05: 1(-0.275,0.5)
  rrect67% 0.4x0.3 smd paste-0.05 mask-0.05: 2(-0.3,0) 3(-0.3,-0.5) 4(0.3,-0.5) 5(0.3,0) 6(0.3,0.5)
  body extent -0.5,-0.72 0.5,0.73, height 0.58
FCC_disclaimer [mil]
Fiducial10-20 [mm]
  round 1 smd mask+0.5: 1(0,0)
  Top Layer keep-out circle w1.178: c0,0 r0.5
FP-0603-L_1_6_0_1-W_0_8_0-IPC_B [mil]
  rect 41.64x35.91 smd paste+0 mask+0: 1(-26.66,0) 2(26.66,0)
  silkscreen extent -47,-34 47,34, body extent -57,-28 57,28, height 10
FP-430481025816_SMT_SW_6MM2_6MM2-MFG [mm]
  rrect7% 2x1.4 smd paste+0 mask+0: 1(-3.5,2) 2(3.5,2) 3(-3.5,-2) 4(3.5,-2)
  silkscreen extent -5.17,-3.2 3.2,3.2, body extent -4.6,-3.3 4.6,3.3, height 0.25
FP-691250610002_CONN_TERM_BLOCK2-MFG [mm]
  rrect4% 2.3x2.3 hole 1.5 paste-1000 mask+0: 1(-2.875,1.65)
  round 2.3 hole 1.5 paste-1000 mask+0: 2(3.475,1.65)
  silkscreen extent -7.52,-6.3 6.85,6.3, body extent -6.95,-6.4 6.95,6.4, height 0.25
FP-691256610002_HDR2-MFG [mm]
  rrect4% 2.45x2.45 hole 1.6 paste-1000 mask+0: 1(-5.08,7.55)
  round 2.45 hole 1.6 paste-1000 mask+0: 1(-5.08,-2.61) 2(5.08,7.55) 2(5.08,-2.61)
  silkscreen extent -11,-9.2 10.21,9.2, body extent -10.31,-9.3 10.31,9.3, height 0.25
FP-885012005058_0402-MFG [mm]
  rrect20% 0.5x0.5 smd paste+0 mask+0: 1(-0.5,0) 2(0.5,0)
  silkscreen extent -0.53,-0.63 0.53,0.63, body extent -0.85,-0.38 0.85,0.38, height 0.25
FP-885012005080_0402-MFG [mm]
  rrect20% 0.5x0.5 smd paste+0 mask+0: 1(-0.5,0) 2(0.5,0)
  silkscreen extent -0.53,-0.63 0.53,0.63, body extent -0.85,-0.38 0.85,0.38, height 0.25
FP-885012006085_0603-MFG [mm]
  rrect13% 0.8x0.8 smd paste+0 mask+0: 1(-0.75,0) 2(0.75,0)
  silkscreen extent -0.85,-0.77 0.85,0.77, body extent -1.25,-0.55 1.25,0.55, height 0.25
FP-885012106008_0603-MFG [mm]
  rrect13% 0.8x0.8 smd paste+0 mask+0: 1(-0.75,0) 2(0.75,0)
  silkscreen extent -0.85,-0.77 0.85,0.77, body extent -1.25,-0.55 1.25,0.55, height 0.25
FP-885012206120_0603-MFG [mm]
  rrect13% 0.8x0.8 smd paste+0 mask+0: 1(-0.75,0) 2(0.75,0)
  silkscreen extent -0.85,-0.77 0.85,0.77, body extent -1.25,-0.55 1.25,0.55, height 0.25
FP-BZX84J-B4V7,115_SC90-MFG [mm]
  rrect17% 0.6x0.6 smd paste-1000 mask+0: 1(-1.1,0) 2(1.1,0)
  silkscreen extent -2.08,-0.67 0.43,0.67, body extent -1.53,-0.82 1.53,0.82, height 0.25
FP-C0805C-DN-MFG [mm]
  rect 0.95x1.35 smd paste+0 mask+0: 1(-0.75,0) 2(0.75,0)
  silkscreen extent -1.1,-1.07 1.1,1.07, body extent -1.4,-0.85 1.4,0.85, height 0.25
FP-CH0402-10RJFPT_0402-MFG [mm]
  rrect20% 0.5x0.65 smd paste+0 mask+0: 1(-0.45,0) 2(0.45,0)
  silkscreen extent -0.8,-0.7 0.8,0.7, body extent -0.8,-0.45 0.8,0.45, height 0.25
FP-EMVY101ARA101MKE0S_RADIAL-MFG [mm]
  rrect4% 5.7x2.5 smd paste+0 mask+0: 1(-4.85,0) 2(4.85,0)
  silkscreen extent -8.37,-6.6 6.6,6.6, body extent -7.95,-6.85 7.95,6.85, height 0.25
FP-SML-LX0603SIW-TR_0603-MFG [mm]
  rrect13% 0.8x0.8 smd paste+0 mask+0: 1(-0.75,0) 2(0.75,0)
  silkscreen extent -1.85,-0.8 0.86,0.8, body extent -1.25,-0.56 1.25,0.56, height 0.25
Fuse_0463 [mm] "SMD, 2-Leads, Body 10.1x3.12mm"
  rrect3% 3.25x3.43 smd: 1(-4.675,0) 2(4.675,0)
  silkscreen extent -2.6,-1.5 2.6,1.5, body extent -5.05,-1.56 5.05,1.56, height 3.12
Harwin_D3082-05 [mm] "Shorting Plug, 10.16mm spacing, TH"
  round 1.8 hole 1.3: 1(-5.08,0) 2(5.08,0)
  silkscreen extent -3.9,-0.53 3.9,0.53, body extent -5.6,-0.52 5.61,0.52, height 6.63
IEC_Caution_Small [mil]
  silkscreen extent -107,-93 107,92
IEC_HotSurface_Small [mil]
  silkscreen extent -107,-93 107,92
Keystone5010 [mil] "Keystone Multipurpose loops"
  round 87 hole 63: 1(0,0)
  silkscreen extent -70,-70 70,70, body extent -63,-63 63,62, height 319
Keystone5011 [mil] "Keystone Multipurpose loops"
  round 87 hole 63: 1(0,0)
  silkscreen extent -70,-70 70,70, body extent -63,-63 63,62, height 319
Keystone5012 [mil] "Keystone Multipurpose loops"
  round 87 hole 63: 1(0,0)
  silkscreen extent -70,-70 70,70, body extent -63,-63 63,62, height 319
KEYSTONE_4822 [mil] "HEX NYLON STANDOFF 6-32, M-F"
  round 1 on Mech4: 0(0,0)
  body extent -144,-125 144,125, height 1251
Keystone_9605 [mil] "Hex Nut,4-40 Thread, 250\" Head Dia"
  body extent -144,-125 144,125, height 100
Label_650x200 [mil] "Thermal Transfer Label"
  round 1 on Mech13: 0(0,0)
  silkscreen extent -325,-100 325,100, body extent -325,-100 325,100, height 1
Molex_1051640001 [mm] "Receptacle, USB 2.0, Micro B, 5 Pos, 0.65mm Pitch, R/A, SMT"
  rrect22% 0.45x1.38 smd: 1(1.3,4.11) 2(0.65,4.11) 3(0,4.11) 4(-0.65,4.11) 5(-1.3,4.11)
  rrect7% 1.475x2.1 smd: 6(-2.462,3.75) 11(2.462,3.75)
  rrect100% 1.4x2.1 hole 0.6 slot 1.3 at 90 deg: 7(-3.95,1.45) 10(3.95,1.45)
  rrect7% 1.375x1.9 smd: 8(-0.938,1.45) 9(0.938,1.45)
  silkscreen extent 1.2,5.1 1.4,5.4, body extent -4.1,-0.7 4.1,4.47, height 2.45
MuRata_CSTNR [mm] "SMD, 3-Leads, Body 4.5x2mm, Pitch 1.5mm"
  rrect25% 0.4x2.6 smd: 1(-1.5,0) 2(0,0) 3(1.5,0)
  body extent -2.3,-1.05 2.3,1.05, height 1.2
ONSC-SOD-323-2-477-02_V [mm] "SOD, 2-Leads, Body 1.7x1.25mm"
  rect 0.63x0.83 smd: 1(-1.115,0) 2(1.115,0)
  silkscreen extent -1.24,-0.67 0.4,1.09, body extent -0.85,-0.63 0.85,0.63, height 1.06
ONSC-SOT-23-3-318-08_V [mm] "SOT23, 3-Leads, Body 2.92x1.3mm, Pitch 0.95mm"
  rect 0.9x0.8 smd: 1(-1,0.95) 2(-1,-0.95) 3(1,0)
  silkscreen extent -1.12,-1.46 0.65,2.02, body extent -0.65,-1.46 0.65,1.46, height 1.11
PZT0100A_N [mm] "QFP, 100-Leads, Body 14x14mm, Pitch 0.50mm, IPC Medium Density"
  oval 1.45x0.3 smd: 1(-7.725,6) 2(-7.725,5.5) 3(-7.725,5) 4(-7.725,4.5) 5(-7.725,4) 6(-7.725,3.5) 7(-7.725,3) 8(-7.725,2.5) 9(-7.725,2) 10(-7.725,1.5) 11(-7.725,1) 12(-7.725,0.5) 13(-7.725,0) 14(-7.725,-0.5) 15(-7.725,-1) 16(-7.725,-1.5) 17(-7.725,-2) 18(-7.725,-2.5) 19(-7.725,-3) 20(-7.725,-3.5) 21(-7.725,-4) 22(-7.725,-4.5) 23(-7.725,-5) 24(-7.725,-5.5) 25(-7.725,-6) 51(7.725,-6) 52(7.725,-5.5) 53(7.725,-5) 54(7.725,-4.5) 55(7.725,-4) 56(7.725,-3.5) 57(7.725,-3) 58(7.725,-2.5) 59(7.725,-2) 60(7.725,-1.5) 61(7.725,-1) 62(7.725,-0.5) 63(7.725,0) 64(7.725,0.5) 65(7.725,1) 66(7.725,1.5) 67(7.725,2) 68(7.725,2.5) 69(7.725,3) 70(7.725,3.5) 71(7.725,4) 72(7.725,4.5) 73(7.725,5) 74(7.725,5.5) 75(7.725,6)
  oval 0.3x1.45 smd: 26(-6,-7.725) 27(-5.5,-7.725) 28(-5,-7.725) 29(-4.5,-7.725) 30(-4,-7.725) 31(-3.5,-7.725) 32(-3,-7.725) 33(-2.5,-7.725) 34(-2,-7.725) 35(-1.5,-7.725) 36(-1,-7.725) 37(-0.5,-7.725) 38(0,-7.725) 39(0.5,-7.725) 40(1,-7.725) 41(1.5,-7.725) 42(2,-7.725) 43(2.5,-7.725) 44(3,-7.725) 45(3.5,-7.725) 46(4,-7.725) 47(4.5,-7.725) 48(5,-7.725) 49(5.5,-7.725) 50(6,-7.725) 76(6,7.725) 77(5.5,7.725) 78(5,7.725) 79(4.5,7.725) 80(4,7.725) 81(3.5,7.725) 82(3,7.725) 83(2.5,7.725) 84(2,7.725) 85(1.5,7.725) 86(1,7.725) 87(0.5,7.725) 88(0,7.725) 89(-0.5,7.725) 90(-1,7.725) 91(-1.5,7.725) 92(-2,7.725) 93(-2.5,7.725) 94(-3,7.725) 95(-3.5,7.725) 96(-4,7.725) 97(-4.5,7.725) 98(-5,7.725) 99(-5.5,7.725) 100(-6,7.725)
  silkscreen extent -8.1,-8.2 8.1,8.2, body extent -8.01,-8.01 8.01,8.01, height 1.6
RESC1005X40X25NL05T05 [mm] "Chip Resistor, 2-Leads, Body 1.05x0.55mm, IPC Medium Density"
  rect 0.55x0.55 smd: 1(-0.45,0) 2(0.45,0)
  body extent -0.53,-0.28 0.53,0.28, height 0.4
RGC0064B [mm] "VQFN-64"
  rrect42% 0.6x0.24 smd mask+0.07: 1(-4.4,3.75) 2(-4.4,3.25) 3(-4.4,2.75) 4(-4.4,2.25) 5(-4.4,1.75) 6(-4.4,1.25) 7(-4.4,0.75) 8(-4.4,0.25) 9(-4.4,-0.25) 10(-4.4,-0.75) 11(-4.4,-1.25) 12(-4.4,-1.75) 13(-4.4,-2.25) 14(-4.4,-2.75) 15(-4.4,-3.25) 16(-4.4,-3.75) 33(4.4,-3.75) 34(4.4,-3.25) 35(4.4,-2.75) 36(4.4,-2.25) 37(4.4,-1.75) 38(4.4,-1.25) 39(4.4,-0.75) 40(4.4,-0.25) 41(4.4,0.25) 42(4.4,0.75) 43(4.4,1.25) 44(4.4,1.75) 45(4.4,2.25) 46(4.4,2.75) 47(4.4,3.25) 48(4.4,3.75)
  rrect42% 0.24x0.6 smd mask+0.07: 17(-3.75,-4.4) 18(-3.25,-4.4) 19(-2.75,-4.4) 20(-2.25,-4.4) 21(-1.75,-4.4) 22(-1.25,-4.4) 23(-0.75,-4.4) 24(-0.25,-4.4) 25(0.25,-4.4) 26(0.75,-4.4) 27(1.25,-4.4) 28(1.75,-4.4) 29(2.25,-4.4) 30(2.75,-4.4) 31(3.25,-4.4) 32(3.75,-4.4) 49(3.75,4.4) 50(3.25,4.4) 51(2.75,4.4) 52(2.25,4.4) 53(1.75,4.4) 54(1.25,4.4) 55(0.75,4.4) 56(0.25,4.4) 57(-0.25,4.4) 58(-0.75,4.4) 59(-1.25,4.4) 60(-1.75,4.4) 61(-2.25,4.4) 62(-2.75,4.4) 63(-3.25,4.4) 64(-3.75,4.4)
  rrect2% 4.25x4.25 smd paste-2.112: 65(0,0)
  body extent -4.5,-4.5 4.5,4.5, height 1
Samtec_SSQ-110-03-x-D [mm] "Receptacle, 2.54mm, 10x2, TH"
  rect 1.55x1.55 hole 1.02: 1(-11.43,1.27)
  round 1.55 hole 1.02: 2(-11.43,-1.27) 3(-8.89,1.27) 4(-8.89,-1.27) 5(-6.35,1.27) 6(-6.35,-1.27) 7(-3.81,1.27) 8(-3.81,-1.27) 9(-1.27,1.27) 10(-1.27,-1.27) 11(1.27,1.27) 12(1.27,-1.27) 13(3.81,1.27) 14(3.81,-1.27) 15(6.35,1.27) 16(6.35,-1.27) 17(8.89,1.27) 18(8.89,-1.27) 19(11.43,1.27) 20(11.43,-1.27)
  silkscreen extent -12.95,-2.48 12.95,3, body extent -12.95,-2.48 12.95,2.48, height 8.51
Samtec_TSM-108-01-x-DV [mm] "Header, 2.54mm, 8x2, SMT"
  rect 3.68x1.27 smd: 1(-2.475,8.89) 2(2.475,8.89) 3(-2.475,6.35) 4(2.475,6.35) 5(-2.475,3.81) 6(2.475,3.81) 7(-2.475,1.27) 8(2.475,1.27) 9(-2.475,-1.27) 10(2.475,-1.27) 11(-2.475,-3.81) 12(2.475,-3.81) 13(-2.475,-6.35) 14(2.475,-6.35) 15(-2.475,-8.89) 16(2.475,-8.89)
  silkscreen extent -1.65,-10.16 1.65,10.3, body extent -3.85,-10.16 3.85,10.16, height 9.65
SSOP28_N [mm] "SOP, 28-Leads, Body 10.2x5.3mm, Pitch 0.65mm, IPC Medium Density"
  oval 2.1x0.45 smd: 1(-3.45,4.225) 2(-3.45,3.575) 3(-3.45,2.925) 4(-3.45,2.275) 5(-3.45,1.625) 6(-3.45,0.975) 7(-3.45,0.325) 8(-3.45,-0.325) 9(-3.45,-0.975) 10(-3.45,-1.625) 11(-3.45,-2.275) 12(-3.45,-2.925) 13(-3.45,-3.575) 14(-3.45,-4.225) 15(3.45,-4.225) 16(3.45,-3.575) 17(3.45,-2.925) 18(3.45,-2.275) 19(3.45,-1.625) 20(3.45,-0.975) 21(3.45,-0.325) 22(3.45,0.325) 23(3.45,0.975) 24(3.45,1.625) 25(3.45,2.275) 26(3.45,2.925) 27(3.45,3.575) 28(3.45,4.225)
  silkscreen extent -3.57,-5.3 2,5.3, body extent -2.7,-5.3 2.7,5.3, height 2
Sullins_PBC02SAAN [mm] "Sullins 100mil, 1x2, 230 mil above insulator"
  rect 1.65x1.65 hole 1.016: 1(0,1.27)
  round 1.65 hole 1.016: 2(0,-1.27)
  silkscreen extent -1.37,-2.54 1.27,3.1, body extent -1.27,-2.54 1.27,2.54, height 8.38
Testpoint_Keystone_Miniature [mil] "Miniature SMT test point"
  rect 135x70 smd: 1(0,0)
  silkscreen extent -78,-46 78,45, body extent -52,-20 52,20, height 61
TI_Stacked_Overlay_Small [mil]
  silkscreen extent -418,-98 418,98
TP_H045P075 [mm] "TP_H0.45P0.75"
  round 0.75 hole 0.45: 1(0,0)
WEEE_Minimum [mil] "WEEElie bin"
  silkscreen extent -95,-172 99,104
WL-SMCW_GREEN [mm] "WURTH"
  rect 0.8x0.8 smd: 1(-0.8,0) 2(0.8,0)
  silkscreen extent -1.9,-0.8 1.2,0.8, body extent -0.85,-0.45 0.85,0.45, height 0.8
WL-SMCW_RED [mm] "WURTH"
  rect 0.8x0.8 smd: 1(-0.8,0) 2(0.8,0)
  silkscreen extent -1.9,-0.8 1.2,0.8, body extent -0.85,-0.45 0.85,0.45, height 0.8
WL-SMCW_YELLOW [mm] "WURTH"
  rect 0.8x0.8 smd: 1(-0.8,0) 2(0.8,0)
  silkscreen extent -1.9,-0.8 1.2,0.8, body extent -0.85,-0.45 0.85,0.45, height 0.8
Wurth_60900213421 [mil] "Shunt, 2.54mm, Black"
  round 1 on Mech3: 0(0,0)
  body extent -98,-48 98,48, height 338
WURTH_61300311121 [mm] "Header, 2.54mm, 3x1, TH"
  rrect50% 1.65x1.65 hole 1.15: 1(-2.54,0)
  round 1.65 hole 1.15: 2(0,0) 3(2.54,0)
  body extent -3.81,-1.27 3.81,1.27, height 8.54
Wurth_61301421121 [mm] "Header, 2.54mm, 7x2, TH"
  rrect50% 1.65x1.65 hole 1.1: 1(-1.27,7.62)
  round 1.65 hole 1.1: 2(1.27,7.62) 3(-1.27,5.08) 4(1.27,5.08) 5(-1.27,2.54) 6(1.27,2.54) 7(-1.27,0) 8(1.27,0) 9(-1.27,-2.54) 10(1.27,-2.54) 11(-1.27,-5.08) 12(1.27,-5.08) 13(-1.27,-7.62) 14(1.27,-7.62)
  body extent -2.54,-8.89 2.54,8.89, height 8.55
XTAL_MS3V-T1R [mm] "Micro Crystal Switzerland recommended land pattern"
  rect 1.1x0.6 smd: 1(-2.775,0.45) 2(-2.775,-0.45)
  rect 2.4x1.5 smd: 3(2.775,0)
  silkscreen extent -1.9,-0.74 1.2,0.74, body extent -3.05,-0.74 3.65,0.74, height 1.42

## Part data
A1 A2 A3 A4 TP13 TP14 TP15 TP16 TP17 TP37 TP38 TP39 TP40 TP41 TP42 TP43 TP44 TP45 TP46: library part CMP-0055149-1, "Test Point, Multipurpose, White, TH", Color=White, Manufacturer=Keystone, Supplier Part Number 1=36-5012-ND
C1 C2 C3 C4 C5 C6: library part CMP-0006250-2, "CAP, CERM, 33 pF, 50 V, +/- 5%, C0G/NP0, 0402", Alternate Manufacturer="Wurth Electronics", Alternate PartNumber=885012005058, Cap_Case=0402, Manufacturer=TDK, Supplier Part Number 1=445-1241-1-ND, TempCo=C0G/NP0, Tolerance_%=5%, Value1=Unknown, Value2=50V, ValueDisplayed=33pF
C7 C8 C9 C10 C11 C12 C15 C62: library part CMP-0006221-1, "CAP, CERM, 0.1 uF, 10 V, +/- 20%, X5R, 0402", Cap_Case=0402, Manufacturer="Wurth Elektronik", Supplier Part Number 1=732-7487-1-ND, TempCo=X5R, Tolerance_%=20%, Value1=Unknown, Value2=10V, ValueDisplayed=0.1uF
C13 C29: library part CMP-0097299-1, "0.47 µF ±20% 10V Ceramic Capacitor X5R 0603 (1608 Metric)", Digikey Part Number=732-7905-1-ND, Manufacturer="Wurth Electronics", Mouser Part Number=710-885012106008, Operating Temperature Range="-55°C to +85°C", TempCo=15%, Temperature Characteristic=X5R, Tolerance_%=20%, ValueDisplayed=470nF