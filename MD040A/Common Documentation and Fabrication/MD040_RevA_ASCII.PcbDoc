# Altium PCB MD040_RevA_ASCII.PcbDoc (part 5 of 6)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 5000 x 5000 mil, 4 copper layers (Top Layer, Signal Layer 1, Signal Layer 2, Bottom Layer), stack 61.2 mil thick; 342 components, 206 nets, 933 pads, 352 vias.
Unrouted connection lines stored in the file: 124.

## Via types
v1: diameter 19.68, hole 13.78, Top Layer to Bottom Layer, tented both sides, 230 vias
v2: diameter 19.68, hole 7.87, Top Layer to Bottom Layer, 87 vias
v3: diameter 19.68, hole 13.78, Top Layer to Bottom Layer, tented bottom, 31 vias
v4: diameter 141.73, hole 141.73, Top Layer to Bottom Layer, tented both sides, 4 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
GND: C1.2 C2.2 C3.2 C4.2 C5.2 C6.2 C7.1 C8.1 C9.1 C10.1 C11.1 C12.2 C13.2 C14.2 C15.1 C16.2 C17.2 C18.2 C19.2 C20.2 C21.2 C22.2 C23.2 C24.2 C25.2 C26.1 C27.1 C28.2 C29.2 C30.2 C31.2 C32.2 C33.2 C34.2 C35.2 C36.2 C37.2 C38.2 C39.2 C40.2 C41.2 C42.2 C43.2 C44.2 C45.2 C46.2 C47.2 C48.2 C49.2 C52.1 C53.1 C54.2 C55.2 C56.2 C57.2 C58.2 C59.2 C61.1 C62.1 C63.1 C64.1 C66.1 C67.2 C68.2 C69.2 C70.2 C71.2 C72.2 C73.1 C74.2 D1.1 D2.1 D13.2 J1.4 J2.2 J3.9 J9.9 J10.13 J10.14 J12.1 J15.1 J15.2 J21.1 J21.2 J23.1 J28.1 J28.2 L2.2 R49.1 R60.1 R61.1 R77.1 R78.1 R84.1 R85.1 R86.1 R87.1 R93.1 R94.1 R95.1 R96.1 R104.1 R105.2 R106.2 R107.2 R108.2 R109.2 R110.1 R111.1 R113.1 R114.1 R115.1 R116.1 R117.1 R118.1 S1.3 S1.4 TP25.1 TP29.1 U1.10 U1.12 U1.15 U1.26 U1.29 U1.63 U1.76 U1.83 U1.90 U2.14 U2.16 U2.39 U2.49 U2.56 U2.65 U3.4 U3.9 U4.7 U4.18 U4.21 U4.25 U4.26 U5.2 U5.4 U5.5 U5.7 U5.11 U6.4 U7.3 U7.10 U7.13 U7.20 U7.22 U7.23 U7.45 Y1.2 Y2.3 | length 12280.9
  Top Layer w6: v1@1104.33,4333.76 v1(1108.27,4333.76) ; C48.2@1393.91,4464.69 1433.44,4464.69 v1(1433.95,4464.18)
  Top Layer w10: R107.2@68.44,1507 R107.2@70.44,1509 ; TP25.1@91,1175 179.56,1086.44 R113.1@349.92,1086.44 350.61,1085.75 R115.1@475.7,1085.75 480.21,1090.27 R111.1@601.14,1090.27 720.93,1090.27 R116.1@721.19,1090.01 852.26,1090.01 R117.1@852.88,1090.63 ; C7.1@110,1738.87 v1@143.87,1738.87 ; D2.1@335.39,4361.73 366.14,4361.73 426.12,4421.72 426.12,4436.17 486.11,4496.16 C23.2@508,4496.16 ; C73.1@453,2056 453.29,2055.71 C72.2@453.29,2006.84 ; D1.1@455.83,4357.37 486.58,4357.37 492.5,4363.28 v1(492.5,4416.39) ; C29.2@486.58,4177.52 v1(486.58,4205.08) ; C16.2@513.62,1511 513.62,1527.53 624.85,1638.76 U1.26@691.82,1638.76 691.82,1676.82 703,1688 739.38,1688 750.87,1676.51 U1.29@750.87,1638.76 750.87,1598.68 665.19,1513 C13.2@631.62,1513 ; C15.1@537,1937.32 559.15,1937.32 584.42,1962.58 U1.12@623.91,1962.58 673.58,1962.58 676,1965 ; U1.15@623.91,1903.53 661.34,1903.53 676,1918.19 676,1965 ; U1.10@623.91,2001.95 664.14,2001.95 676,1990.1 676,1965 ; C8.1@650,2424.68 v1@650,2470.37 ; C33.2@679.13,4249.77 682.43,4253.07 739.45,4253.07 C32.2@741.58,4255.19 743.7,4253.07 793.19,4253.07 C25.2@795.32,4255.19 ; C9.1@700,2422.63 v1@700,2470.86 ; C10.1@750,2431.31 751.7,2433.02 751.7,2471.68 C11.1@799.6,2471.68 ; C18.2@867.38,2366 867.38,2345.5 869.41,2345.5 888.67,2326.24 U1.90@888.67,2247.03 ; U2.39@1021.54,3857.04 1076.98,3801.59 1076.98,3791.03 v1(1094.49,3773.52) 1067.37,3746.4 1067.37,3725.6 C34.2@1080.92,3712.06 ; U1.83@1026.46,2247.03 1026.46,2281.57 1045.9,2301 v1(1105.61,2301) 1107.61,2299 1148,2299 1164.26,2282.74 U1.76@1164.26,2247.03 ; v1(1029.63,4094.36) 1049.37,4114.11 U2.56@1049.37,4115.94 ; v1(1076.77,4361.32) v1@1104.33,4333.76 ; v1@1087,118.45 J2.2@1166.94,118.45 ; v1@1127.9,2409.6 R109.2@1157,2409.6 ; U2.49@1146.81,4018.31 1189.77,4018.31 v1(1202.43,4005.66) ; C28.2@1171.55,4235.89 1171.55,4237.85 v1(1211.7,4278) ; C30.2@1203.02,4204.4 1241.83,4243.21 v1(1250,4243.21) ; U1.63@1232.17,1942.9 1388.08,1942.9 1425.6,1905.38 C17.2@1463.2,1905.38 1495.62,1905.38 ; C20.2@1234.11,4173.45 1234.11,4184.01 v1(1269.69,4219.59) ; C38.2@1245.71,4419.33 1237.74,4427.3 1194.59,4427.3 C40.2@1189.27,4432.62 1189.27,4436.56 1172.31,4453.53 1168.47,4453.53 1158.35,4463.65 1158.35,4522.95 1237.54,4522.95 C35.2@1238.67,4521.77 C36.2@1281.11,4521.79 ; R108.2@1246.45,2409.65 v1@1284.96,2409.65 ; C36.2@1281.11,4521.79 C37.2@1325.16,4521.77 ; R77.1@1323.05,4055.65 1326.22,4055.65 v1(1344.49,4073.92) ; v1(1334.3,2542.08) 1340.49,2548.26 C74.2@1429.28,2548.26 ; C26.1@1338.3,3562 v1(1338.3,3600) ; C21.2@1388,3859 1397,3859 v1(1433,3823) 1522.39,3912.39 C45.2@1563,3912.39 1563.85,3911.54 U5.4@1677.05,3911.54 U5.11@1743.97,3911.54 ; v1(1491.39,4703.85) 1491.39,4701.23 1495.5,4697.12 1495.5,4683.3 U6.4@1496.4,4682.39 ; 1494.14,1905.38 1515.68,1883.84 1561.5,1883.84 C14.2@1563.52,1881.82 v1@1620.18,1881.82 ; C27.1@1494.24,3306 1501.81,3313.56 1698.56,3313.56 1739,3354 C12.2@1739,3393.31 ; 1544.78,4336 1544.78,4364.76 v1(1549.21,4369.2) ; L2.2@1559.22,4596.22 1600.78,4596.22 v1(1613,4584) ; U5.5@1677.05,3891.86 1724.29,3891.86 U5.11@1743.97,3911.54 ; U5.2@1677.05,3950.91 1743.97,3950.91 U5.11@1763.66,3931.23 U5.11@1743.97,3911.54 ; S1.3@1736.14,2278.42 1874,2278.42 ; C47.2@1809.62,4773.03 R78.1@1809.62,4836 1809.62,4869.82 v1(1811,4871.19) ; U4.7@1829.44,4411.8 v1@1898.8,4411.8 ; U5.7@1850.27,3911.54 1882.1,3911.54 1895.48,3898.16 1895.48,3854.94 1911.48,3838.94 C46.2@1951.48,3838.94 ; v1(1874,2197) 1874,2278.42 ; v1(1953,3781) 1953,3837.42 C46.2@1951.48,3838.94 ; S1.4@2021.6,2278.42 1874,2278.42 ; R49.1@2024.44,2680.83 2025.42,2680.83 2039.12,2667.13 2039.12,2661.46 2039.32,2661.27 C19.2@2039.32,2609 2035.85,2605.54 2035.85,2570.47 2032.69,2567.31 v1(2034,2566) ; C44.2@2062.63,3910.84 1990.73,3838.94 C46.2@1951.48,3838.94 ; U4.18@2101.09,4309.43 2163.43,4309.43 2179.69,4325.69 C41.2@2200,4325.69 2200,4358.61 2172.41,4386.2 U4.21@2101.09,4386.2 ; U4.26@2101.09,4514.16 U4.25@2101.09,4488.57 v1@2189,4488.57 ; v1@2634.23,4677.68 D13.2@2673.76,4677.68 2673.76,4593.42 R118.1@2678.56,4588.61 ; C1.2@2643.95,285.38 2646.95,288.38 C2.2@2731,288.38 2797.02,288.38 J1.4@2866.94,218.45 2867.05,218.45 2919.5,166 3099,166 3205.13,272.13 4191.28,272.13 4192.3,273.15 4199.15,273.15 v1(4201,275) ; v1@2666.39,759.39 C4.2@2704.47,759.39 ; v1(2666.5,877.5) C5.2@2704.47,877.5 ; v1@2668,639 2668.13,639 2668.25,638.88 C3.2@2704.47,638.88 ; v1@2668.61,995.61 C6.2@2704.47,995.61 ; v1@2861,2562 2861.97,2561.03 C62.1@2861.97,2521 ; v1@2950,3391 R84.1@2981.32,3391 ; v1@2955.92,2621 2955.92,2617.08 2987.01,2585.99 R85.1@3002.54,2585.99 ; v1@2966.4,3003.4 3012.32,3003.4 3011.32,3002.4 R86.1@3011.32,2956 ; v1@3499.84,2991.59 C63.1@3535.87,2955.56 ; C49.2@3621,2970.53 3685.25,2970.53 3727.93,2927.85 U7.23@3727.93,2835.67 ; U7.45@3853.92,2302.86 3853.92,2188.08 3933,2109 4025.98,2109 C56.2@4035.98,2099 ; v2(3863.61,2573.33) 3901.27,2535.67 4189.67,2535.67 4227.21,2573.21 C57.2@4227.21,2575 ; U7.45@3875.57,2573.33 U7.45@3875.57,2717.57 ; U7.45@3902.43,2577.82 3931.61,2607 U7.45@3952.7,2607 ; U7.45@3947.71,2789.71 U7.45@3875.57,2717.57 ; U7.45@3956.38,2610.67 4193.33,2610.67 4227.21,2576.79 C57.2@4227.21,2575 ; U7.45@3962.18,2789.71 3966.22,2785.67 U7.20@4023.21,2785.67 ; U7.3@4023.21,2360.67 4069.72,2360.67 4115.79,2314.6 4157.91,2314.6 C58.2@4159.51,2313 ; C59.2@4145.19,2904.17 4059.17,2904.17 4023.21,2868.21 4023.21,2835.67 3964.84,2835.67 3875.57,2746.4 U7.45@3875.57,2717.57 ; v1@4201,273.49 4245.03,273.49 4279.66,273.49 4288.53,264.62 R104.1@4325.24,264.62 ; v1(4534.89,3680.11) C64.1@4568.3,3646.7 ; C61.1@4621.38,2575.07 4621.31,2575 C57.2@4227.21,2575 ; C66.1@4625.47,2679.86 4625.74,2679.6 4625.74,2633.89 4626.62,2633 4626.62,2575.22 C61.1@4626,2574.6 ; C68.2@4750,1140.11 4750,1139.9 4756,1139.9 4757.92,1137.98 R94.1@4798.39,1137.98 ; C69.2@4756,866.29 4757.92,864.37 4807.73,864.37 R95.1@4818.48,853.62 v1@4818.48,827.52 ; C70.2@4757,562.11 4758.92,560.19 4807.25,560.19 R96.1@4818,549.44 v1@4818,510.5 ; C67.2@4758,1455.11 4758.92,1454.19 4806.25,1454.19 R93.1@4817,1443.44 ; v1(4811,1096) 4810.86,1096.14 4809.14,1096.14 4811,1098 R94.1@4811,1125.37 ; v1@4815,1408 R93.1@4815,1443.44 ; R94.1@4798.39,1137.98 R94.1@4809.14,1127.23 R94.1@4811,1125.37 ; R94.1@4798.39,1137.98 R94.1@4811,1125.37
  other v1: 1084.61,119 4273.67,505.65 4370.67,505.65 4818.4,509 2668.61,639 4275.67,734.65 4371.67,736.65 2666.61,760 4819,826 4275.67,954.65 4371.67,956.65 2668.61,996 542.99,1088 4275.67,1174.65 4371.67,1176.65 4275.67,1394.65 4371.67,1396.65 4815.38,1405.62 97,1601 4275.67,1614.65 4371.67,1616.65 1408,1630 647.61,1638.95 1131,1737 147.61,1739 4275.67,1834.65 4371.67,1836.65 1621.61,1882 849,2117 3772.16,2215 3908.47,2215 3820,2216 3863.4,2216 3952.46,2216 3771.43,2256.33 3819.05,2257.57 3864.13,2257.57 3907.75,2259 3951,2259 883.75,2314.6 1285.61,2409.46 1122.53,2410.5 650,2470 700,2471.06 752,2472.22 2861,2564 2955,2622 4626,2633 1831.81,2689.1 3284,2765 3776.16,2889 3912.47,2889 3824,2890 3867.4,2890 3956.46,2890 3775.43,2930.33 3823.05,2931.57 3868.13,2931.57 3911.75,2933 3499,2993.78 2966.61,3004 1700,3317 2950.61,3392 4051.4,3879.72 541.67,4269.04 581.04,4269.04 616.48,4269.04 679.13,4381.01 1902,4414 679.13,4420.37 1587.92,4433.85 2191,4490 683.07,4510.93 1159,4523 683.07,4554.24 88.58,4665.35 2632.81,4678.06
  other v2: 3776.99,2313.49 3820.3,2313.49 3863.61,2313.49 3906.92,2313.49 3950.22,2313.49 3776.99,2356.8 3820.3,2356.8 3863.61,2356.8 3906.92,2356.8 3950.22,2356.8 3776.99,2400.1 3820.3,2400.1 3863.61,2400.1 3906.92,2400.1 3950.22,2400.1 3776.99,2443.41 3820.3,2443.41 3863.61,2443.41 3906.92,2443.41 3950.22,2443.41 3776.99,2486.72 3820.3,2486.72 3863.61,2486.72 3906.92,2486.72 3950.22,2486.72 3776.99,2530.02 3820.3,2530.02 3863.61,2530.02 3906.92,2530.02 3950.22,2530.02 3776.99,2573.33 3820.3,2573.33 3906.92,2573.33 3950.22,2573.33 3776.99,2616.64 3820.3,2616.64 3863.61,2616.64 3906.92,2616.64 3950.22,2616.64 3776.99,2659.94 3820.3,2659.94 3863.61,2659.94 3906.92,2659.94 3950.22,2659.94 3776.99,2703.25 3820.3,2703.25 3863.61,2703.25 3906.92,2703.25 3950.22,2703.25 3776.99,2746.56 3820.3,2746.56 3863.61,2746.56 3906.92,2746.56 3950.22,2746.56 3776.99,2789.87 3820.3,2789.87 3863.61,2789.87 3906.92,2789.87 3950.22,2789.87 3776.99,2833.17 3820.3,2833.17 3863.61,2833.17 3906.92,2833.17 3950.22,2833.17 1738.07,3880.05 1789.25,3880.05 887.07,3928.67 952.77,3928.67 1738.07,3931.23 1789.25,3931.23 919.92,3961.52 848.38,3967.36 991.47,3967.36 1738.07,3982.41 1789.25,3982.41 881.23,4000.21 958.62,4000.21 848.38,4033.06 991.47,4033.06 919.92,4038.91 887.07,4071.76 952.77,4071.76 1380.69,4320.09 1356.09,4339.77 1405.3,4339.77 1380.69,4359.46
GUI_STATUS: D8.2 U1.35 | length 758.5
  Top Layer w10: D8.2@349.92,1279.83 349.92,1367.28 387.65,1405 701.79,1405 868.08,1571.3 868.08,1638.76 U1.35@868.98,1638.76
ID1: R99.2 R105.1 U1.33 | length 920.7
  Top Layer w10: R105.1@124.56,1343 125.56,1342 126.56,1343 R99.2@183.44,1343 209.94,1343 209.94,1320.94 217.48,1313.39 259.64,1313.39 267.18,1320.94 267.18,1358.29 349.64,1440.75 686.98,1440.75 828.71,1582.48 828.71,1638.76 U1.33@829.61,1638.76
ID2: R100.2 R106.1 U1.32 | length 829.4
  Top Layer w10: R106.1@123.56,1421.84 134.13,1411.27 172.69,1411.27 183.44,1422.02 183.44,1448 194.07,1458.63 679.58,1458.63 809.93,1588.98 U1.32@809.93,1638.76
ID3: R101.2 R107.1 U1.31 | length 777
  Top Layer w10: R107.1@125.56,1509 127.56,1511 R101.2@184.44,1511 192.99,1502.45 192.99,1485.86 198.85,1480 671,1480 790.24,1599.24 U1.31@790.24,1638.76
ID4: R102.2 R108.1 U1.84 | length 454.5
  Top Layer w10: U1.84@1006.78,2247.03 1006.78,2294.78 1067.51,2355.51 1179.51,2355.51 1202,2378 1202,2443.53 1223.24,2464.76 R108.1@1246.45,2464.76 R102.2@1246.45,2523.04
ID5: R103.2 R109.1 U1.85 | length 392.3
  Top Layer w10: 988,2277.45 988,2247.94 U1.85@987.09,2247.03 987.09,2318.09 1120.36,2451.36 1131.14,2462.14 1131.14,2464.72 R109.1@1157,2464.72 R103.2@1157,2523
"INDEXER HOME": D11.2 U1.39 | length 451.9
  Top Layer w10: D11.2@720.5,1281 720.5,1347.89 946.82,1574.2 946.82,1637.86 U1.39@947.72,1638.76
M0/nSCS/VREF1/EN4_2: J4.16 J26.2 | length 455.3
  Top Layer w10: J4.16@2616.7,2896.98 2743.67,2896.98 ; J26.2@2734,2652 2780.78,2652 2806.31,2677.53 2806.31,2834.38 2743.68,2897
MANUAL_VREF: C19.1 J7.2 R44.1 R49.2 | length 282
  Top Layer w10: C19.1@2078.68,2609 2079.18,2608.51 2079.56,2608.51 J7.2@2196.49,2608.51 ; C19.1@2079.67,2612 2079.67,2673.07 R49.2@2087.43,2680.83 R44.1@2087.43,2760 ; J7.2@2196.49,2608.51 J7.2@2201,2613.02 J7.2@2196.49,2608.51
MCU_3V3: C12.1 C14.1 C16.1 C17.1 C18.1 C63.2 D5.2 D7.2 J10.10 R1.1 R4.1 R20.2 R22.2 R29.1 R35.1 R44.2 R83.2 R88.2 R99.1 R100.1 R101.1 R102.1 R103.1 TP27.1 U1.25 U1.64 U1.87 U1.89 U7.25 | length 12896.2
  Top Layer w10: R4.1@145.19,1856.48 R35.1@212.83,1856.48 ; R99.1@238.56,1343 249.31,1353.75 249.31,1380.14 251.54,1382.38 v1(251.54,1385) ; R100.1@238.56,1423 249.31,1412.25 249.31,1389.86 254.16,1385 v1@255,1385 ; R101.1@239.56,1511 C16.1@466.38,1511 623.91,1668.53 U1.25@623.91,1706.68 669.68,1706.68 v1@696,1733 ; J10.10@872,3335.02 872,3282.01 917.65,3236.37 917.65,3002.47 944.21,2975.9 1081.79,2975.9 1117.65,3011.76 1117.65,3040.04 1144.21,3066.61 1181.79,3066.61 1208.35,3040.04 1208.35,2917.48 v1(1219.83,2906) ; U1.87@947.72,2247.03 947.72,2199.72 938,2190 927,2190 ; R22.2@1193.69,2902 1215.83,2902 v1(1219.83,2906) ; v3(1219.83,2698.69) 1232.95,2711.81 1843.48,2711.81 1891.67,2760 R44.2@2024.44,2760 ; R20.2@1245.31,2904 1243.31,2906 v1(1219.83,2906) ; R102.1@1246.45,2578.16 1157.04,2578.16 R103.1@1157,2578.12 951.12,2578.12 914.62,2541.62 C18.1@914.62,2366 908.35,2359.73 U1.89@908.35,2247.03 908.35,2196.65 915,2190 927,2190 ; 1486.14,1952.62 1517.7,1984.18 C14.1@1563.52,1984.18 ; 1487.62,1952.62 C17.1@1463.2,1952.62 1453.24,1962.58 U1.64@1232.17,1962.58 1178.42,1962.58 1147,1994 1050,1994 1011,1955 952.61,1955 927,1980.61 927,2190 ; C12.1@1739,3432.69 1739,3473.69 1711.69,3501 1664.5,3501 D5.2@1657,3508.5 1657,3675 TP27.1@1656,3676 3024.81,3676 D7.2@3123.81,3577 ; R1.1@3115.76,115.69 3116.46,115 v1(3164,115) ; D7.2@3128,3576 3235,3469 3235,3295.35 3452.5,3077.85 3452.5,2949.78 3501.84,2900.44 3535.87,2900.44 3541.94,2900.44 3579,2863.38 R83.2@3579,2821.56 3619.11,2821.56 3655,2785.67 U7.25@3727.93,2785.67 ; v1@3482,2857 3499,2840 R88.2@3499,2820.78 R88.2@3497.22,2820.78
  Bottom Layer w10: v1(169,1858) 314,1858 435.61,1736.39 506,1736.39 ; v1(251.54,1385) 506,1639.46 506,1736.39 ; J10.10@872,3335.02 872,3346.65 917.35,3392 917.35,3471.51 953.34,3507.5 1482.5,3507.5 1651,3676 TP27.1@1656,3676 ; v1(926.98,2008.18) 695.72,1776.92 v1(695.72,1736.39) 506,1736.39 ; v1(1202.61,2577.56) 1202.61,2583.39 1219.83,2600.61 v1(1219.83,2906) ; v1@3166,118 3183,118 3214,149 3214,2546.24 3475.87,2808.12 3475.87,2852.55 v1(3483,2859.67) 3487.79,2864.46 v1(3577.67,2864.46)
MCU_UARTRXD: J10.8 U1.61 | length 1963.9
  Top Layer w10: v1@1070,1967.9 v1@1072.56,1967.9 ; v1(1072.56,1970) 1122,1970 1188.47,1903.53 U1.61@1232.17,1903.53
  Bottom Layer w10: J10.8@972,3335.02 1075.3,3231.72 1293.67,3231.72 1358,3167.39 1358,2398.85 1070,2110.85 v1@1070,1967.9
MCU_UARTTXD: J10.6 U1.60 | length 1911.7
  Top Layer w10: v1(1105,1911) 1132.16,1883.84 U1.60@1232.17,1883.84
  Bottom Layer w10: J10.6@1072,3335.02 1145.84,3261.18 1301.82,3261.18 1401,3162 1401,2410 1105.05,2114.05 v1@1105.05,1912
MODE2/IPROPI4: J4.8 J16.2 R14.1 R79.2 U7.29 | length 4347.7
  Top Layer w10: R14.1@2562.61,922.78 2562.61,1161.22 3017.22,1615.83 v1(3017.22,1618.84) ; J4.8@2616.7,3296.98 2618.72,3299 2775,3299 2853,3221 3060.42,3221 J16.2@3118,3278.58 ; R79.2@3114.69,3395 3118,3391.69 J16.2@3118,3278.58 ; U7.29@3727.93,2685.67 3488,2685.67 3374.87,2798.8 3374.87,3016.97 3118,3273.85 J16.2@3118,3278.58
  Bottom Layer w10: v1(3017.22,1618.84) 3017.22,2431 3019,2431 3237,2649 3237,3157 3207,3187 3207,3189.58 J16.2@3118,3278.58
MODE/MODE1: J4.6 R11.1 U7.28 | length 4965.2
  Top Layer w10: R11.1@1450.41,718.45 1494.45,718.45 2367.28,1591.28 2437.28,1591.28 v1(2459,1613) ; J4.6@2616.7,3396.98 2745.98,3396.98 v1(2782,3433) 3130,3433 3178,3385 3178,3258 3395,3041 3395,2814.67 3499,2710.67 U7.28@3727.93,2710.67
  Bottom Layer w10: v1(2459,1613) 2666.13,1820.13 2666.13,2515.36 2686.52,2535.75 2686.52,3337.52 v1(2782,3433)
MSP_DECAY0/SDI/DECAY/EN1: J8.5 U1.65 | length 1298.8
  Top Layer w10: U1.65@1232.17,1982.27 1468.23,1982.27 1542.18,2056.22 2075.28,2056.22 2264.06,2245 J8.5@2422.15,2245
MSP_DECAY1/SDO/RSVD/EN2: J8.3 U1.66 | length 1332.1
  Top Layer w10: U1.66@1232.17,2001.95 1462.64,2001.95 1561.06,2100.38 2001.33,2100.38 2245.95,2345 J8.3@2422.15,2345
MSP_DIR/IN2/PH2: J8.11 U1.52 | length 1281
  Top Layer w10: U1.52@1232.17,1726.36 1563.93,1726.36 1618.31,1780.75 1939.47,1780.75 2021.6,1862.87 2168.94,1862.87 2251.57,1945.5 2316.29,1945.5 2316.79,1945 J8.11@2422.15,1945
MSP_ENABLE/IN1/PH1: J8.13 U1.51 | length 1247.3
  Top Layer w10: U1.51@1232.17,1706.68 1569.52,1706.68 1625.72,1762.87 1946.87,1762.87 2029,1845 J8.13@2422.15,1845
MSP_IPROPI1/IPROPI2: C10.2 R41.1 U1.98 | length 2081.7
  Top Layer w10: U1.98@731.19,2247.03 731.19,2373.13 C10.2@750,2391.94 749.51,2391.94 724,2417.45 724,2596.28 921.86,2794.14 1736.14,2794.14 2039,3097 R41.1@2230.22,3097
MSP_IPROPI2/IPROPI3: C9.2 R40.1 U1.99 | length 2154.9
  Top Layer w10: C9.2@700,2383.26 699.51,2383.26 677.28,2405.49 677.28,2582.1 913.18,2818 1679,2818 2057.98,3196.98 R40.1@2228.66,3196.98 ; C9.2@701.66,2383.26 701.66,2330.92 711.5,2321.08 U1.99@711.5,2247.03
MSP_M0/nSCS/VREF1/EN4: J4.15 R54.2 TP15.1 U1.3 | length 3358.2
  Top Layer w10: U1.3@623.91,2139.75 562.84,2139.75 524,2178.59 524,2560.37 TP15.1@358.01,2726.36 378.85,2726.36 398.48,2746 590.45,2746 R54.2@659.45,2815 ; v1@922.99,2680 990.55,2747.56 1828.67,2747.56 1977.8,2896.69 2169,2896.69 2169.3,2896.98 2216.38,2896.98 J4.15@2421.82,2896.98
  Signal Layer 2 w10: TP15.1@358.01,2726.36 542.75,2541.62 689.62,2541.62 828,2680 v1@922.99,2680
  other v1: 922,2680
MSP_M1/SCLK/IN4/PH4: J8.7 R3.1 U1.54 U1.62 | length 1911.1
  Top Layer w10: U1.62@1232.17,1923.21 1374.79,1923.21 1445.19,1852.81 ; R3.1@1344.66,1570.18 1344.66,1571.17 1273.81,1642.01 1247.64,1642.01 1187.54,1702.11 1187.54,1750.61 1201.76,1764.83 1222.28,1764.83 1222.28,1764.9 1223.11,1765.73 1359.22,1765.73 1402.2,1808.72 1402.2,1809.82 1445.19,1852.81 ; J8.7@2422.15,2145 2420.15,2143 2187.34,2143 1885.72,1841.39 1523.88,1841.39 1512.46,1852.81 1445.19,1852.81
MSP_M1_PD: R3.2 U1.50 | length 167.5
  Top Layer w10: U1.50@1164.26,1638.76 1164.26,1616.13 1198.47,1581.92 1278.79,1581.92 1289.54,1571.17 R3.2@1289.54,1570.18
MSP_MODE2/IPROPI4: C8.2 R39.1 U1.100 | length 2248.7
  Top Layer w10: C8.2@650,2385.31 649.51,2385.31 627.28,2407.54 627.28,2560.1 911.18,2844 1620,2844 2075,3299 R39.1@2230.32,3299 ; C8.2@651.24,2385.31 651.24,2337.76 691.82,2297.18 U1.100@691.82,2247.03
MSP_MODE/MODE1: J4.5 U1.67 | length 2180.5
  Top Layer w10: v1(1171,2023) 1201.3,2023 1201.76,2022.54 1231.27,2022.54 U1.67@1232.17,2021.64 ; v1@1533,2892 2037.98,3396.98 J4.5@2421.82,3396.98
  Bottom Layer w10: v1(1171,2023) 1171,2104 1339.07,2272.07 1339.07,2275.21 1458.81,2394.95 1458.81,2816.81 v1(1535,2893)
MSP_nFAULT: J4.1 U1.24 | length 3552.5
  Top Layer w10: v1(507,1595) 576,1664 576,1716.52 584.94,1725.46 623,1725.46 U1.24@623.91,1726.36
  Top Layer w15: v1@742,2870 1391,2870 2117.98,3596.98 J4.1@2421.82,3596.98
  Signal Layer 1 w15: v1@508,1596 624,1712 624,2752 v1(741,2869)
MSP_nHOME/OCPM: J4.3 U1.38 | length 2683
  Top Layer w10: U1.38@928.04,1638.76 928.04,1698 1060.04,1830 v1@1063,1830 ; v1@1491,2894.54 2093.44,3496.98 J4.3@2421.82,3496.98
  Bottom Layer w10: v1@1063,1830 1082.6,1830 1138.3,1885.7 1138.3,2114 1434,2409.7 1434,2838 v1(1491,2895)
  other v1: 1060,1829
MSP_nSCS: R54.1 U1.59 | length 1380
  Top Layer w10: R54.1@698.82,2815 698.82,2669.92 606,2577.1 606,2267 713.78,2159.22 713.78,2158.35 1007.97,1864.16 U1.59@1232.17,1864.16
MSP_nSLEEP: J8.15 U1.41 | length 1720.5
  Top Layer w10: U1.41@987.09,1638.76 988,1639.67 988,1526.09 1085.54,1428.56 1316.68,1428.56 1633.12,1745 J8.15@2422.15,1745
MSP_RSVD/IPROPI1: C11.2 R42.1 U1.97 | length 1994.2
  Top Layer w10: U1.97@750.87,2247.03 750.87,2327.4 799.6,2376.12 C11.2@799.6,2432.31 811.31,2432.31 834.19,2455.19 834.19,2668.99 938.2,2773 1788,2773 2011,2996 R42.1@2229.63,2996
MSP_STEP/IN3/PH3: J8.9 U1.53 | length 1313.8
  Top Layer w10: U1.53@1232.17,1746.05 1558.33,1746.05 1610.91,1798.62 1932.07,1798.62 2014.19,1880.75 2137.28,1880.75 2301.54,2045 J8.9@2422.15,2045
MSP_TOFF/RSVD/EN3: J8.1 R2.1 U1.22 | length 2216.9
  Top Layer w10: R2.1@513.67,1717.39 562.01,1765.73 U1.22@623.91,1765.73 759.62,1765.73 879,1885.11 v1@879,1885 ; v1@962.74,1977.74 1335,2350 2119,2350 2214,2445 2274.48,2445 J8.1@2422.15,2445
  Bottom Layer w10: v1(878,1886) 965,1973 v1(965,1979)
MSP_TOFF_PD: R2.2 U1.23 | length 156.5
  Top Layer w10: R2.2@513.67,1662.27 555,1703.6 555,1723.4 577.65,1746.05 U1.23@623.91,1746.05
MSP_VREF/VREF2: J6.2 TP17.1 U1.4 | length 2677.1
  Top Layer w10: TP17.1@406.16,2578.12 416.53,2588.49 470.61,2588.49 506.13,2552.97 506.13,2171.18 556.34,2120.97 623,2120.97 U1.4@623.91,2120.06 ; v1(923,2647) 1005.69,2729.69 1836.07,2729.69 1985.2,2878.81 2110.69,2878.81 2201,2788.5 J6.2@2201,2753
  Signal Layer 2 w10: TP17.1@406.16,2578.12 480.98,2578.12 535.35,2523.75 697.03,2523.75 820.28,2647 v1(923,2647)
NetC1_1: C1.1 J1.10 TP40.1 | length 821.9
  Top Layer w10: C1.1@2643.95,332.62 2643.95,423 2645.55,423 2741,518.45 J1.10@2866.94,518.45 2918.5,570 3303.24,570 TP40.1@3311.24,562
NetC2_1: C2.1 J1.8 TP39.1 | length 947.4
  Top Layer w10: C2.1@2731,335.62 2729.94,336.68 2729.94,420.81 2864.58,420.81 J1.8@2866.94,418.45 2912.39,373 3073,373 3108.5,408.5 3178.5,408.5 3245.5,475.5 3392.67,475.5 3438.67,521.5 TP39.1@3510.44,521.5
NetC7_2: C7.2 R4.2 U1.9 | length 683.3
  Top Layer w10: C7.2@110,1778.24 110,1856.24 R4.2@109.76,1856.48 109.76,1894.76 143,1928 246,1928 292.55,1974.55 495,1974.55 542.09,2021.64 U1.9@623.91,2021.64
NetC13_1: C13.1 U1.27 | length 216.5
  Top Layer w10: C13.1@584.38,1513 584.38,1532.12 613.26,1561 678.28,1561 711.5,1594.23 U1.27@711.5,1638.76
NetC15_2: C15.2 R35.2 U1.11 | length 427.7
  Top Layer w10: R35.2@248.26,1856.48 342.78,1951 501.65,1951 527.34,1976.69 C15.2@537,1976.69 542.58,1982.27 U1.11@623.91,1982.27
NetC26_2: C26.2 J10.1 R64.2 | length 257.1
  Top Layer w10: R64.2@1179.43,3570.39 1222.61,3570.39 1231,3562 C26.2@1291.06,3562 ; J10.1@1272,3435.02 1294.38,3457.4 1294.38,3564.2 C26.2@1294.38,3567.71
NetC27_2: C27.2 J10.3 R65.2 | length 512.2
  Top Layer w10: R65.2@1080.08,3570.39 1172,3478.47 J10.3@1172,3435.02 ; v1(1400,3303) 1403,3306 C27.2@1447,3306
  Bottom Layer w10: J10.3@1172,3435.02 1225.02,3382 1334.3,3382 1400,3316.3 v1(1400,3303)
NetC38_1: C38.1 C40.1 R68.1 U3.1 | length 551.3
  Top Layer w10: C40.1@1189.27,4385.38 1194.59,4380.06 1235.83,4380.06 1235.83,4366.22 C38.1@1245.71,4356.33 1245.71,4355.35 1259.41,4341.65 1260.4,4341.65 1272.91,4329.13 v1(1272.91,4327.85) 1316.11,4284.65 U3.1@1342.31,4284.65 ; v1(1482.04,4123.42) 1482.04,4081.18 R68.1@1482.5,4080.73
  Bottom Layer w10: v1(1272.91,4327.85) 1323.6,4277.16 1346.06,4277.16 1413.13,4210.09 1413.13,4192.34 v1(1482.04,4123.42)
NetC39_1: C39.1 U3.3 | length 138.5
  Top Layer w10: C39.1@1319.09,4192.22 1319.09,4226.85 1352.2,4259.97 1378.19,4259.97 1393.49,4275.27 U3.3@1393.49,4284.65
NetC45_1: C45.1 R74.1 U5.1 | length 214.4
  Top Layer w10: R74.1@1481.72,3994.83 1508.68,3994.83 1543.87,3959.64 C45.1@1563,3959.64 1612.52,3959.64 1623.48,3970.6 U5.1@1677.05,3970.6
NetC46_1: C46.1 U5.8 | length 106.3
  Top Layer w10: U5.8@1850.27,3931.23 1894.27,3931.23 1906.56,3918.94 C46.1@1951.48,3918.94
NetC50_1: C50.1 U7.44 | length 106.8
  Top Layer w10: C50.1@3627.8,2265.92 3631.46,2265.92 3676.37,2310.83 U7.44@3715.97,2310.83
NetC50_2: C50.2 U7.43 | length 96.2
  Top Layer w10: C50.2@3627.8,2319.25 3637.05,2319.25 3655,2337.2 3714.61,2337.2 U7.43@3715.97,2335.83
NetC51_2: C51.2 U7.1 | length 106.2
  Top Layer w10: U7.1@4011.25,2310.83 4019.47,2302.61 C51.2@4019.47,2208
NetC62_2: C62.2 J5.2 R19.2 | length 1708.3
  Top Layer w10: v1(2671,1219) 2675.66,1214.34 R19.2@2675.66,1102 ; v1(2784,2522.77) 2785.77,2521 C62.2@2822.59,2521 2822.59,2601.85 J5.2@2874,2653.25
  Bottom Layer w10: v1(2671,1219) 2671,1614 2838,1781 2838,2470.85 2835.92,2470.85 v1(2784,2522.77)
NetC72_1: C72.1 U1.13 Y2.1 | length 408.6
  Top Layer w6: v1(461.35,1927.15) 462.26,1928.06 509.22,1928.06 522.65,1914.63 560.41,1914.63 588.67,1942.9 U1.13@623.91,1942.9
  Top Layer w10: Y2.1@334.62,2010.7 376.65,2010.7 ; v1(375.67,2028.65) 375.67,2011.68 376.65,2010.7 ; C72.1@406.04,2006.84 402.19,2010.7 376.65,2010.7
  Bottom Layer w10: v1(375.67,2028.65) 377.52,2026.8 377.52,2010.98 v1(461.35,1927.15)
NetC73_2: C73.2 U1.14 Y2.2 | length 495.4
  Top Layer w6: v1(497.2,1907.35) 503.79,1900.76 566.15,1900.76 585.7,1920.31 621,1920.31 U1.14@623.91,1923.21
  Top Layer w10: Y2.2@334.62,2046.13 Y2.2@343,2046.13 ; v1@343,2083 343.67,2082.33 343.67,2046.8 Y2.2@343,2046.13 ; C73.2@404,2056.36 375.4,2056.36 371.28,2052.24 349.11,2052.24 Y2.2@343,2046.13
  Bottom Layer w10: v1@343,2083 344.32,2083 375.95,2051.37 385.08,2051.37 497.2,1939.25 v1(497.2,1907.35)
  other v1: 343.67,2083.65
NetD1_2: D1.2 R58.1 | length 138.1
  Top Layer w10: R58.1@413.2,4168.39 413.2,4251.74 D1.2@451.9,4290.44
NetD2_2: D2.2 R59.1 | length 119.9
  Top Layer w10: R59.1@334.39,4174.55 D2.2@334.39,4294.48
NetD3_2: D3.2 L1.2 | length 127.4
  Top Layer w10: L1.2@1256.1,4651.81 1273.91,4634 D3.2@1324.94,4634 1351.81,4607.12 v1(1351.81,4593.9)
NetD4_1: D4.1 Q1.3 | length 97
  Top Layer w10: Q1.3@2943.44,4627.5 2968.55,4602.39 D4.1@3030.06,4602.39
NetD5_1: D5.1 R110.2 | length 77.3
  Top Layer w10: R110.2@1655.89,3368.68 1657,3369.79 D5.1@1657,3445.5
NetD6_1: D6.1 R114.2 | length 77.5
  Top Layer w10: R114.2@229.56,1139.56 230.07,1140.07 D6.1@230.07,1216.81
NetD7_1: D7.1 R112.2 | length 70.3
  Top Layer w10: R112.2@2990.56,3577 D7.1@3060.82,3577
NetD8_1: D8.1 R113.2 | length 75.3
  Top Layer w10: R113.2@349.92,1141.56 D8.1@349.92,1216.84
NetD9_1: D9.1 R115.2 | length 76.6
  Top Layer w10: R115.2@472.78,1141.82 475.6,1144.65 D9.1@475.6,1217.25
NetD10_1: D10.1 R111.2 | length 72.5
  Top Layer w6: R111.2@601.14,1145.38 D10.1@601.14,1217.86
NetD11_1: D11.1 R116.2 | length 73.2
  Top Layer w10: D11.1@720.5,1218.01 720.5,1145.81 R116.2@721.19,1145.13
NetD12_1: D12.1 R117.2 | length 73.1
  Top Layer w10: R117.2@852.88,1145.75 854.91,1147.77 D12.1@854.91,1218
NetD13_1: D13.1 Q1.1 R97.1 | length 284.5
  Top Layer w10: D13.1@2760.37,4677.68 2800.05,4677.68 2812.83,4664.9 Q1.1@2864.7,4664.9 2868.72,4668.92 R97.1@3037.93,4668.92
NetF1_2: F1.2 J12.2 TP36.1 | length 1321.6
  Top Layer w10: J12.2@3712.24,4715.76 J12.2@3715,4713
  Top Layer w100: TP36.1@3409,4715.76 J12.2@3712.24,4715.76 ; J12.2@3715,4313 3803.21,4313 4019.15,4097.06 F1.2@4238,4097.06 ; J12.2@3717,4311 J12.2@3717,4713
NetJ1_6: J1.6 TP38.1 | length 516.1
  Top Layer w10: J1.6@2866.94,318.45 2912.39,273 3043,273 3147,377 3227.69,377 3228.69,378 TP38.1@3320.69,378
NetJ2_4: J2.4 TP46.1 | length 478.1
  Top Layer w10: TP46.1@689,218 689.45,218.45 J2.4@1166.94,218.45
NetJ3_2: J3.2 R20.1 | length 123.3
  Top Layer w10: J3.2@1264.65,3019 1264.65,2957.65 1284.13,2938.17 1284.13,2904.55 R20.1@1284.68,2904
NetJ3_4: J3.4 R22.1 | length 121.3
  Top Layer w10: R22.1@1154.32,2902 1154.32,2937.31 1164.65,2947.65 J3.4@1164.65,3019
NetJ4_7: J4.7 R39.2 | length 153
  Top Layer w10: R39.2@2269.69,3299 2271.7,3296.98 J4.7@2421.82,3296.98
NetJ4_9: J4.9 R40.2 | length 153.8
  Top Layer w10: R40.2@2268.03,3196.98 J4.9@2421.82,3196.98
NetJ4_11: J4.11 R41.2 | length 152.2
  Top Layer w10: R41.2@2269.59,3097 J4.11@2421.82,3096.98
NetJ4_13: J4.13 R42.2 | length 153.2
  Top Layer w10: R42.2@2269,2996 2269.98,2996.98 J4.13@2421.82,2996.98
NetJ9_2: J9.2 R63.2 | length 181
  Top Layer w10: R63.2@1120.08,4597.54 1120.08,4625.1 1146.7,4651.72 1146.7,4767.13 J9.2@1146.43,4767.4
NetJ9_4: J9.4 R62.2 | length 187.2
  Top Layer w10: J9.4@1046.43,4767.4 1046.25,4767.23 1046.25,4691.05 1080.71,4656.6 ; R62.2@1081.15,4593.9 1081.15,4655.99
NetJ10_5: J10.5 R66.2 | length 173.1
  Top Layer w10: R66.2@980.99,3570.45 1072,3479.44 J10.5@1072,3435.02
NetJ10_7: J10.7 R67.2 | length 173.2
  Top Layer w10: R67.2@880.72,3570.39 972,3479.11 J10.7@972,3435.02
NetJ11_1: J11.1 L1.1 | length 229.6
  Top Layer w10: L1.1@1256.1,4714.8 1416.45,4714.8 1434.68,4733.03 J11.1@1434.68,4776.46
NetJ11_5: J11.5 L2.1 | length 126.4
  Top Layer w10: J11.5@1537.04,4776.46 1537.04,4681.39 L2.1@1559.22,4659.22
NetJ16_1: J16.1 R79.1 R84.2 | length 171.8
  Top Layer w10: J16.1@3018,3279 3021.69,3282.69 3021.69,3394 3025.69,3390 R79.1@3074.32,3390 ; R79.1@3074.32,3395 R79.1@3075.32,3395
NetJ17_1: J17.1 R80.1 R85.2 | length 167.5
  Top Layer w10: J17.1@3036,2700.59 3041.91,2694.68 3041.91,2585.99 R80.1@3092.32,2585.99
NetJ18_1: J18.1 R81.1 R86.2 | length 170.7
  Top Layer w10: J18.1@3040.12,2843.7 3040.12,2902.12 3050.69,2912.69 3050.69,2956 3103.38,2956 R81.1@3104.32,2956.93
NetJ20_1: J20.1 R82.1 R87.2 | length 171
  Top Layer w10: J20.1@3041,3118 3041,3062.94 3051.69,3052.25 3051.69,3003.4 R82.1@3103.63,3003.4
NetJ27_2: J27.2 S1.1 | length 185.1
  Top Layer w10: S1.1@1740.2,2425.13 1740.2,2526.2 1760,2546 J27.2@1760,2602
NetQ1_2: Q1.2 R118.2 | length 131.6
  Top Layer w10: R118.2@2733.68,4588.61 2735.16,4590.1 Q1.2@2864.7,4590.1
NetTP1_1: TP1.1 U1.17 | length 349.4
  Top Layer w10: TP1.1@317.77,1761.28 318.55,1760.5 378.5,1760.5 379.66,1760.5 483.31,1864.16 U1.17@623.91,1864.16
NetTP2_1: TP2.1 U1.18 | length 297.7
  Top Layer w10: TP2.1@388.67,1720 388.67,1738.67 494.47,1844.47 U1.18@623.91,1844.47
NetTP3_1: TP3.1 U1.19 | length 366.2
  Top Layer w10: TP3.1@320.21,1683 379.47,1683 416.31,1719.83 416.31,1726.31 514.79,1824.79 U1.19@623.91,1824.79
NetTP4_1: TP4.1 U1.20 | length 316.6
  Top Layer w10: TP4.1@390,1646 451.64,1707.64 451.64,1736.36 520.38,1805.1 U1.20@623.91,1805.1
NetTP5_1: TP5.1 U1.21 | length 402.2
  Top Layer w10: TP5.1@319.77,1604.33 389.33,1604.33 484.06,1699.06 484.06,1738.47 531.01,1785.42 U1.21@623.91,1785.42
NetTP6_1: TP6.1 U1.42 | length 128.8
  Top Layer w10: U1.42@1006.78,1638.76 1006.78,1553 1032.53,1527.25 TP6.1@1032.53,1520.65
NetTP7_1: TP7.1 U1.44 | length 204
  Top Layer w10: U1.44@1046.15,1638.76 1046.15,1564.85 1062,1549 1062,1492.19 TP7.1@1098,1456.19
NetTP8_1: TP8.1 U1.45 | length 131.6
  Top Layer w10: U1.45@1065.83,1638.76 1065.83,1588.81 1095.65,1559 1095.65,1520.02 TP8.1@1096,1519.67
NetTP9_1: TP9.1 U1.46 | length 155.8
  Top Layer w10: U1.46@1085.52,1638.76 1085.52,1598.52 1165.35,1518.68 TP9.1@1168,1518.68
NetTP10_1: TP10.1 U1.55 | length 119.2
  Top Layer w10: U1.55@1232.17,1785.42 1339.82,1785.42 TP10.1@1348.01,1793.61
NetTP11_1: TP11.1 U1.56 | length 160.5
  Top Layer w10: U1.56@1232.17,1805.1 1317.1,1805.1 TP11.1@1370.56,1858.57
NetTP12_1: TP12.1 U1.57 | length 96.9
  Top Layer w10: U1.57@1232.17,1824.79 1268.93,1824.79 TP12.1@1311.48,1867.34
NetTP13_1: TP13.1 U1.2 | length 576.3
  Top Layer w10: TP13.1@545.86,2670.95 545.86,2182.01 568.43,2159.43 U1.2@623.91,2159.43
NetTP14_1: TP14.1 U1.16 | length 224.1
  Top Layer w10: TP14.1@404,1894 414.16,1883.84 U1.16@623.91,1883.84
NetTP16_1: TP16.1 U1.88 | length 279.7
  Top Layer w10: U1.88@928.04,2247.03 928.04,2311.04 983,2366 TP16.1@983,2504.01
NetTP18_1: TP18.1 U1.68 | length 205.6
  Top Layer w10: U1.68@1232.17,2041.32 1349.12,2041.32 1356.55,2033.89 1379.45,2033.89 1386.88,2041.32 1431.22,2041.32 TP18.1@1431.47,2041.58
NetTP19_1: TP19.1 U1.69 | length 136
  Top Layer w10: U1.69@1232.17,2061.01 1367.48,2061.01 TP19.1@1368,2061.53
NetTP20_1: TP20.1 U1.70 | length 209.9
  Top Layer w10: U1.70@1232.17,2080.69 1304.69,2080.69 1315,2091 1417.95,2091 TP20.1@1432,2105.05
NetTP21_1: TP21.1 U1.71 | length 146
  Top Layer w10: U1.71@1232.17,2100.38 1296.08,2100.38 1320.7,2125 TP21.1@1368,2125
NetTP22_1: TP22.1 U1.72 | length 221.9
  Top Layer w10: U1.72@1232.17,2120.06 1286.5,2120.06 1334.97,2168.53 TP22.1@1434,2168.53
NetTP23_1: TP23.1 U1.73 | length 160.9
  Top Layer w10: U1.73@1232.17,2139.75 1280.91,2139.75 1341.45,2200.29 TP23.1@1368,2200.29
NetTP24_1: TP24.1 U1.74 | length 229.9
  Top Layer w10: U1.74@1232.17,2159.43 1270.96,2159.43 1343.53,2232 TP24.1@1432,2232
NetTP26_1: TP26.1 U1.75 | length 169.6
  Top Layer w10: U1.75@1232.17,2179.12 1265.37,2179.12 1350.01,2263.76 TP26.1@1366.71,2263.76
nFAULT: J4.2 R6.1 R83.1 R112.1 U7.26 | length 4080.2
  Top Layer w10: J4.2@2616.7,3596.98 2716,3596.98 2733.98,3579 2792.06,3579 2794.06,3577 ; R112.1@2935.44,3577 2794.06,3577 ; R6.1@3113.8,821.4 v1@3157.4,821.4 ; v1(3458,2907) 3433.29,2931.71 3433.29,3066.71 3216,3284 3216,3441 3151.02,3505.98 2834.83,3505.98 2794.81,3546 2795.06,3546.25 2795.06,3576 2794.06,3577 ; v1@3464,2913 3539,2838 3539,2779.44 3552,2766.44 R83.1@3579,2766.44 3584.77,2760.67 U7.26@3727.93,2760.67
  Bottom Layer w10: v1(3159.41,821) 3149.61,830.8 3149.61,2525 3458,2833.39 v1(3458,2907)
nHOME/OCPM: J4.4 R9.1 R88.1 U7.27 | length 5618.3
  Top Layer w10: R9.1@1450.41,113.72 1524,113.72 1699,288.72 1699,378 v1(2343,1022) ; J4.4@2616.7,3496.98 2749.98,3496.98 ; 2749,3496 2749.98,3496.98 ; U7.27@3727.93,2735.67 3516.33,2735.67 3499,2753 R88.1@3499,2765.66 3471.34,2765.66 3440.5,2796.5 3440.5,2881.71 3415.41,2906.8 3415.41,3052 3197.15,3270.26 3197.15,3421 3157.28,3460.87 2786.13,3460.87 2750.02,3496.98
  Bottom Layer w10: v1@2344,1022 2344,1605 2330,1619 2638,1927 2638,2515.59 2668.65,2546.24 2668.65,3351.77 2782.87,3466 v1(2784,3466)
nSCS/M0/EN4/VREF1/VREF: J25.1 J26.1 R23.1 U7.34 | length 3841.7
  Top Layer w10: R23.1@1445.68,925 1620.72,925 2332.44,1636.72 2501.58,1636.72 2518.3,1620 v1(2520,1620) ; J25.1@2572.62,2753 2733,2753 J26.1@2734,2752 ; v1(2726,2529.56) 2726,2527.8 2759.8,2494 3514,2494 3514.36,2493.64 3581.4,2560.67 U7.34@3727.93,2560.67
  Bottom Layer w10: v1(2520,1620) 2520,1648.72 2684,1812.72 2684,2487.56 2779.35,2582.91 2779.35,2682.27 v1(2761.03,2700.59) 2761.03,2724.96 J26.1@2734,2752
nSLEEP: J8.16 R34.1 U7.42 | length 3281.4
  Top Layer w10: R34.1@1450.41,420.81 1633.81,420.81 2617.03,1404.03 J8.16@2617.03,1745 2986.24,1745 2987,1744.24 3603.43,2360.67 U7.42@3727.93,2360.67
PUSH: J27.3
RST/SBWTDIO: C74.1 J3.11 J10.4 J27.1 R29.2 U1.96 | length 2974.8
  Top Layer w10: U1.96@770.56,2247.03 770.56,2319.25 781.54,2330.22 781.54,2331.82 867.39,2417.67 867.39,2524.06 954,2610.67 1651.33,2610.67 J27.1@1660,2602 1606.26,2548.26 C74.1@1488.34,2548.26
  Bottom Layer w10: J3.11@763,3121.26 763,3172 792,3201 896.05,3201 920,3224.95 920,3357.36 943,3380.36 943,3383 1104,3383 1151.98,3335.02 J10.4@1172,3335.02 1218.02,3289 1304,3289 1660,2933 J27.1@1660,2602
RSVD/IPROPI1: J4.14 J17.2 R21.1 R80.2 U7.32 | length 3700.1
  Top Layer w10: J4.14@2616.7,2996.98 2755,2996.98 ; 2755,2994 2765,2994 3004,2755 3081.59,2755 J17.2@3136,2700.59 3136,2647.31 3131.69,2643 R80.2@3131.69,2585.99 3425.01,2585.99 3449.69,2610.67 U7.32@3715.97,2610.67
  Top Layer w12: v1(2562,639) 2562.61,638.39 R21.1@2562.61,590.26
  Bottom Layer w10: v1(2562,639) 2562,697.94 2813,948.94 2813,1517 2979.35,1683.35 2979.35,2482.57 3136,2639.22 J17.2@3136,2700.59
RSVD/IPROPI2/IPROPI1/IPROPI: J4.12 J18.2 J19.2 R18.1 R81.2 U7.31 | length 4028.4
  Top Layer w10: v1@2563,753 2563.56,752.44 R18.1@2563.56,706.24 ; J4.12@2616.7,3096.98 2756,3096.98 2944,2908.98 2944,2842.12 3003.99,2782.13 3078.55,2782.13 J18.2@3140.12,2843.7 3140.81,2843 3143.69,2843 3266,2843 3473.33,2635.67 U7.31@3727.93,2635.67 ; J18.2@3143.69,2847.27 3143.69,2897 ; R81.2@3143.69,2956.93 3143.69,2897 ; J19.2@3283.79,2894.54 3146.14,2894.54 3143.69,2897
  Bottom Layer w10: v1(2564.14,754) 2581,754 2791,964 2791,1536.08 2953,1698.08 2953,2491.51 3088.41,2626.92 3088.41,2791.99 J18.2@3140.12,2843.7
RSVD/IPROPI3/IPROPI2/IPROPI: J4.10 J19.1 J20.2 R17.1 R82.2 U7.30 | length 4106.1
  Top Layer w10: R17.1@2562.61,823.65 2521,865.27 2521,1179.61 2958,1616.61 v1(2958,1618) ; J4.10@2616.7,3196.98 2636.7,3176.98 3082.02,3176.98 3142,3117 3142,3004.4 R82.2@3143,3003.4 J19.1@3274.93,3003.4 ; J19.1@3277.93,3013.4 3277.93,3000.4 3357,2921.33 3357,2791.4 3487.72,2660.67 U7.30@3727.93,2660.67
  Bottom Layer w10: v1@2958,1616.61 2999.35,1661.35 2999.35,2459 3205,2664.65 3205,3054 J20.2@3141,3118
RSVD/TOFF/EN3: J8.2 R24.1 U7.35 | length 4050.1
  Top Layer w10: R24.1@1451.37,218.45 1545.55,218.45 1662.55,335.45 1662.55,383.75 2784,1505.2 2784,1613 v1@2788,1617 ; J8.2@2617.03,2445 3491,2445 3581.67,2535.67 U7.35@3727.93,2535.67
  Bottom Layer w10: v1(2784,1618) 2798.86,1618 2923,1742.14 v1(2923,2446)
RX: R70.1 U4.5 | length 105.2
  Top Layer w10: R70.1@1724.63,4463.9 1828.52,4463.9 U4.5@1829.44,4462.98
SCLK/M1/IN4/RSVD: J8.8 R27.1 U7.38 | length 2731.3
  Top Layer w10: J8.8@2617.03,2145 2619.34,2142.69 v1(3119,2142.69) 3271.98,2142.69 3274.3,2145 3589.97,2460.67 U7.38@3727.93,2460.67 ; R27.1@3113.8,714.12 3113.91,714 v1@3157,714
  Bottom Layer w10: v1(3119,2142.69) 3119,1198 3119,755.41 v1(3159.41,715)
SDI/DECAY0/EN1/DECAY: J8.6 R26.1 U7.37 | length 3520
  Top Layer w10: R26.1@1445.37,613.3 1447.34,613.3 1452.18,618.14 1452.18,640.18 2385.41,1573.41 2529.41,1573.41 v1(2576,1620) ; J8.6@2617.03,2245 3345.28,2245 3583.65,2483.37 3583.65,2485.67 U7.37@3727.93,2485.67
  Bottom Layer w10: v1(2576,1620) 2629,1620 2792,1783 v1(2792,2247)
SDO/DECAY1/EN2/RSVD: J8.4 R25.1 U7.36 | length 3442.3
  Top Layer w10: R25.1@1444.68,816 1545,816 2343,1614 v1(2390,1614) ; J8.4@2617.03,2345 3417.7,2345 3583.37,2510.67 U7.36@3727.93,2510.67
  Bottom Layer w10: v1(2390,1614) 2410,1614 2437,1587 2522.14,1587 2544.14,1609 2544.14,1624.86 2715.42,1796.13 2718,1796.13 v1(2718,2348)
STEP/IN3/RSVD: J8.10 R30.1 U7.39 | length 3025.4
  Top Layer w10: R30.1@1447.68,1016 1680.34,1016 2318.93,1654.59 2447.39,1654.59 2507.46,1714.67 2507.46,1982.87 2569.59,2045 3199.58,2045 3590.25,2435.67 U7.39@3727.93,2435.67
T_RST_RST: R65.1 U2.43 | length 382.7
  Top Layer w10: 1089.1,3900.83 1077.21,3912.72 1164.16,3825.77 1164.16,3734.64 1113.48,3683.96 R65.1@1113.48,3603.8
T_TEST_TCKC: R64.1 U2.44 | length 373.2
  Top Layer w10: U2.44@1091.13,3926.64 1188.37,3829.4 1188.37,3659.5 1212.84,3635.03 R64.1@1212.84,3603.8
TB0CLK: U1.43 U1.58 | length 325.3
  Top Layer w10: U1.43@1026.46,1638.76 1026.46,1697.5 1173.44,1844.47 U1.58@1232.17,1844.47
TCK: J3.7 U1.95 | length 945.8
  Top Layer w10: U1.95@790.24,2247.03 790.24,2297.24 v1(803,2310)
  Bottom Layer w10: v1(803,2310) 803,2777 909,2883 909,3067.26 J3.7@963,3121.26
TDI: J3.3 U1.93 | length 1056.6
  Top Layer w10: U1.93@829.61,2247.03 v1(829.61,2339)
  Bottom Layer w10: v1(829.61,2339) 846,2355.39 846,2780.02 1015,2949.02 1015,3048 1043.56,3076.56 1044.21,3075.9 1117.65,3075.9 J3.3@1163,3121.26
TDO: J3.1 U1.92 | length 1191.3
  Top Layer w10: v1@849.3,2178.3 U1.92@849.3,2247.03
  Bottom Layer w10: v1(851,2181) 874.69,2203.69 874.69,2267.59 861.03,2281.25 861.03,2345.14 863.87,2347.98 863.87,2654 1208.35,2998.48 1208.35,3066.61 J3.1@1263,3121.26
TMS: J3.5 U1.94 | length 1316.9
  Top Layer w10: v1@804,2175 809.93,2180.93 U1.94@809.93,2247.03
  Bottom Layer w10: v1@804,2175 778,2201 778,2789.71 810,2821.71 810,3044 838,3072 884.07,3072 915.52,3103.45 915.52,3144.52 941,3170 1014.26,3170 J3.5@1063,3121.26
  other v1: 802,2177
TST/SBWTCK: J3.8 J10.2 U1.91 | length 1872.2
  Top Layer w10: U1.91@868.98,2247.03 868.98,2195.14 873.72,2190.41 873.72,2189.47 v1@892,2171.18 ; J3.8@963,3021.26 1017.65,3075.9 1017.65,3140.04 1086.6,3209 v1(1271.61,3209) ; v1@1271.52,3211.25 1271.52,3335.02 J10.2@1272,3335.02
  Bottom Layer w10: v1(892.61,2171) 1090.14,2368.53 1112.68,2368.53 1308.35,2564.2 1308.35,3172.26 v1(1271.61,3209)
TX: R69.2 U4.1 | length 107.6
  Top Layer w10: R69.2@1723.36,4569 1727.02,4565.34 U4.1@1829.44,4565.34
USB_D_N: J11.2 R72.1 R73.1 U6.2 U6.6 | length 964.6
  Top Layer w10: v1(1425.46,4678) 1429.85,4682.39 U6.6@1457.03,4682.39 1457.94,4683.3 1457.94,4774.13 J11.2@1460.27,4776.46 ; U6.2@1476.4,4659 1476.4,4600.62 v1(1446.79,4571) 1480.94,4536.85 R72.1@1480.94,4450.19 ; v1(1535,4548) 1550.43,4548 1631.77,4466.66 1631.77,4404.11 1670.38,4365.51 R73.1@1670.38,4226.15
  Bottom Layer w10: v1(1425.46,4678) 1425.46,4592.33 v1(1446.79,4571) 1512,4571 v1(1535,4548)
USB_D_P: J11.3 R71.1 R75.1 U6.3 | length 720.3
  Top Layer w10: J11.3@1485.86,4776.46 1489.72,4772.6 1489.72,4745.1 1515.18,4719.64 1515.18,4671.5 1505.32,4661.64 1496.4,4661.64 U6.3@1496.4,4658.77 1512.28,4642.89 1512.28,4538.59 1529.37,4521.5 R75.1@1529.37,4450.19 1529.37,4431.57 1546.52,4431.57 1605.94,4372.15 1605.94,4227 R71.1@1669.76,4163.18
VM: C44.1 C51.1 C53.2 C54.1 C55.1 C56.1 C57.1 C58.1 C59.1 D4.2 F1.1 J23.2 R97.2 R98.2 TP30.1 U5.10 U7.2 U7.11 U7.12 U7.21 | length 5524.1
  Top Layer w10: U5.10@1850.27,3970.6 2056.2,3970.6 C44.1@2062.63,3964.16 3298.49,3964.16 C53.2@3379.38,3883.28 ; R97.2@3085.17,4668.92 3093.05,4661.05 D4.2@3093.05,4602.39 ; C53.2@3378.22,3883.28 C53.2@3379.38,3883.28 ; U7.2@4011.25,2335.83 4014.12,2332.96 4054.4,2332.96 4097.84,2289.51 4097.84,2280.74 v1(4098.58,2280) ; U7.11@4023.21,2560.67 4023.88,2560 v1(4079,2560) 4080.07,2561.07 v1(4106,2561.07) 4152.08,2561.07 4166.01,2575 4154.01,2587 v1(4104.58,2587) 4103.99,2586.41 v1(4079,2586.41) 4078.26,2585.67 U7.12@4023.21,2585.67 ; U7.21@4023.21,2810.67 4076.33,2810.67 v1(4080,2807) 4105.93,2807 v1(4107,2808.07) ; v1(4073,2279.41) 4097.99,2279.41 v1(4098.58,2280) ; C51.1@4078.52,2208 4073.79,2212.73 4073.79,2252.21 v1(4073,2253) 4073.54,2253.54 4099.46,2253.54 v1(4100,2254.07) ; v1(4080,2833.41) 4080.59,2834 v1(4105.58,2834) 4114.56,2842.98 C59.1@4145.19,2842.98 ; C56.1@4157.4,2098.38 4158.02,2099 4158.02,2256.4 C58.1@4159.51,2257.88 4155.7,2254.07 v1(4100,2254.07) ; C53.2@3379.38,3883.28 3382.94,3879.72 3382.94,3883.27 C53.2@3379.38,3883.28 ; v1(4098.58,2280) 4099.29,2279.29 4099.29,2254.78 v1(4100,2254.07)
  Top Layer w15: C56.1@4157.4,2098.38 4157.4,2022.6 4325,1855 R98.2@4325,433.14
  Top Layer w100: v3@4148.63,3347 4148.63,3643.12 4234.46,3728.94 4293.17,3728.94 J23.2@4690.04,4125.81
  Bottom Layer w10: C54.1@3089.77,4297.46 3154.5,4297.46 3158.65,4301.61 v1(3161.27,4301.61) 3159.42,4299.76 3159.42,4285.47 C55.1@3093.02,4219.07 C55.1@3090.15,4219.07
  other v1: 3560.43,3754 3590,3754 3560,3781.67 3589.57,3781.67 3560,3809.33 3589.57,3809.33 3560,3837 3589.57,3837 3559,3864.67 3590,3864.67 3559,3892.33 3590,3892.33 3559,3920 3590,3920 3559,3947.67 3589,3947.67 3559,3975.33 3589,3975.33 3558,4003 3588,4003
  other v3: 4147.5,3310 4185,3337.93 4147.5,3339.17 4110,3340 4185,3365.36 4110,3367.2 4147.5,3368.35 4185,3392.79 4110,3394.4 4147.5,3397.52 4185,3420.22 4110,3421.59 4147.5,3426.7 4185,3447.64 4110,3448.79 4147.5,3455.87 4185,3475.07 4110,3475.99 4147.5,3485.05 4185,3502.5 4110,3503.19 4147.5,3514.22 4110,3530.39 4185,3529.93 4147.5,3543.39 4185,3557.35 4110,3557.58 4147.5,3572.57 4110,3584.78 4185,3584.78
VREF/VREF2: J5.1 J6.1 J7.1 J25.2 U7.33 | length 1954.6
  Top Layer w10: J25.2@2472.62,2753 J6.1@2301,2753 J7.1@2301,2613.02 2301,2606.65 2760.7,2606.65 2824.18,2670.13 2824.18,2703.43 J5.1@2874,2753.25 2930.74,2696.51 2930.74,2608.09 2977.52,2561.31 3425.6,2561.31 3450.12,2585.83 U7.33@3715.97,2585.83
VSEN_AOUT1: C67.1 R5.1 R7.1 R89.1 R93.2 | length 202.5
  Top Layer w10: R5.1@4663,1490.68 R7.1@4705,1490.68 4706.9,1488.79 4756.1,1488.79 C67.1@4758,1486.89 ; C67.1@4760,1486.89 4790.23,1486.89 R93.2@4803.22,1499.87 ; R93.2@4817,1499.05 R89.1@4817,1556.34
VSEN_AOUT2: C68.1 R8.1 R10.1 R90.1 R94.2 | length 312.7
  Top Layer w10: R8.1@4652,1175.68 R10.1@4696,1175.68 4697.9,1173.79 4748.1,1173.79 4750,1171.89 4750,1171.68 4756,1171.68 R94.2@4798.47,1171.68 ; R90.1@4808.22,1270.93 4808.22,1183.28 R94.2@4809.14,1182.35 ; R94.2@4798.47,1171.68 R94.2@4809.14,1182.35 ; R94.2@4798.47,1171.68 R94.2@4809.14,1182.35 ; R94.2@4798.47,1171.68 R94.2@4809.14,1182.35 ; R94.2@4798.47,1171.68 R94.2@4809.14,1182.35 ; R94.2@4798.47,1171.68 R94.2@4809.14,1182.35
VSEN_BOUT1: C69.1 R12.1 R13.1 R91.1 R95.2 | length 233.4
  Top Layer w10: R13.1@4665,901.86 R12.1@4704,901.86 4705.9,899.96 4754.1,899.96 4756,898.07 4756,899.89 4764.84,908.74 R95.2@4818.48,908.74 R91.1@4818.48,981.57
VSEN_BOUT2: C70.1 R15.1 R16.1 R92.1 R96.2 | length 224.8
  Top Layer w10: R16.1@4665,597.68 R15.1@4704,597.68 4705.9,595.79 4755.1,595.79 4757,593.89 4807.33,593.89 R96.2@4818,604.56 ; R96.2@4819.04,605.6 R92.1@4819.04,671.44