# Altium PCB MD040_RevE2.PcbDoc (part 2 of 5)
Units mm, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 127 x 127 mm, 4 copper layers (Top Layer, Signal Layer 1, Signal Layer 2, Bottom Layer), stack 1.554 mm thick; 336 components, 206 nets, 924 pads, 303 vias.
Unrouted connection lines stored in the file: 125.

## Design rules (kind name [scope] priority, off if disabled: settings) (continued)
PolygonConnect PolygonConnect_9 [All vs IsNamedPolygon('TOP_LAYER_VM_P123') Or  IsNamedPolygon('TOP_LAYER_VM_P123') Or  IsNamedPolygon('TOP_LAYER_VM_P123')] p86: connectstyle=Direct reliefconductorwidth=0.254 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=0.254
PolygonConnect PolygonConnect_8 [All vs IsNamedPolygon('TOP_LAYER_NONET_P072')] p87: connectstyle=Direct reliefconductorwidth=0.254 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=0.254
PolygonConnect PolygonConnect_7 [All vs IsNamedPolygon('TOP_LAYER_NONET_P072')] p88: connectstyle=Direct reliefconductorwidth=0.254 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=0.254
PolygonConnect PolygonConnect_6 [All vs IsNamedPolygon('TOP_LAYER_VM_P042')] p89: connectstyle=Direct reliefconductorwidth=0.254 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=0.254
PolygonConnect PolygonConnect_5 [All vs IsNamedPolygon('TOP_LAYER_VM_P044')] p90: connectstyle=Direct reliefconductorwidth=0.254 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=0.254
PolygonConnect PolygonConnect_4 [All vs IsNamedPolygon('TOP_LAYER_VM_P046')] p91: connectstyle=Direct reliefconductorwidth=0.254 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=0.254
PolygonConnect PolygonConnect_3 [All vs IsNamedPolygon('TOP_LAYER_GND_P036') Or  IsNamedPolygon('TOP_LAYER_OUT2_P040') Or  IsNamedPolygon('TOP_LAYER_OUT1_P038')] p92: connectstyle=Direct reliefconductorwidth=0.254 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=0.254
PolygonConnect PolygonConnect_2 [InNet('EZFET_VBUS') vs IsNamedPolygon('TOP_LAYER_EZFET_VBUS_P008')] p93: connectstyle=Direct reliefconductorwidth=0.254 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=0.254
PolygonConnect PolygonConnect_1 [InNetClass('Power-Net') vs IsNamedPolygon('TOP_LAYER_EZFET_USB_SHIELD_P201')] p94: connectstyle=Direct reliefconductorwidth=0.254 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=0.254
PolygonConnect [All] p95: connectstyle=Direct reliefconductorwidth=0.254 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=0.254
RoutingVias ThermalPadVias [IsVia and InAnyComponent] p1: holewidth=0.2 width=0.5 viastyle="Through Hole" minholewidth=0.2 minwidth=0.5 maxholewidth=0.33 maxwidth=0.6
RoutingVias [All] p2: holewidth=0.406 width=0.864 viastyle="Through Hole" minholewidth=0.2 minwidth=0.66 maxholewidth=1.016 maxwidth=1.651
SilkToBoardRegionClearance [Not ((IsComment or IsDesignator) And (Hide <> 'False')) and not InRegion(1000,500,4000,800)] p1:
SilkToSilkClearance SilkToSilkClearance_Pb-FreeLogo [(HasFootprint('Pb-Free_Overlay_Medium') OR HasFootprint('Pb-Free_Overlay_Small')) vs (HasFootprint('Pb-Free_Overlay_Medium') OR HasFootprint('Pb-Free_Overlay_Small'))] p1: silktosilkclearance=0
SilkToSilkClearance [All] p2: silktosilkclearance=0.1
SilkToSolderMaskClearance SilkToComponentPadClearance [(IsPad or IsFill or IsRegion) and InAnycomponent] p1: minsilkscreentomaskgap=0.127 clearancetoexposedcopper=TRUE
SilkToSolderMaskClearance "Silk to Solder Mask Opening" [All] p2: minsilkscreentomaskgap=0.1 clearancetoexposedcopper=FALSE
SolderMaskExpansion [All] p1: expansion=0.05 istentingtop=FALSE
UnRoutedNet [All] p1: checkbadconnections=TRUE
Width [All] p1: maxlimit=2.54 minlimit=0.152 preferedwidth=0.254 checkconnectedcopper=TRUE
14 further rules are at their usual default settings.

## Classes and differential pairs
component class MD040_Motor_control_RevE2: A1 A2 A3 A4 C1 C2 C3 C4 C5 C6 C7 C8 C9 C10 C11 C12 C13 C14 C15 C16 C17 C18 C19 C62 C72 C73 C74 J1 J2 J3 J4 J5 J6 J7 J8 J25 J26 R1 R2 R3 R4 R5 R6 R7 R8 R9 R10 R11 R12 R13 R14 R15 R16 R17 R18 R19 R20 R21 R22 R23 R24 R25 R26 R27 R29 R30 R32 R33 R34 R35 R39 R40 R41 R42 R44 R49 R54 SH-J1 SH-J2 SH-J3 SH-J4 SH-J5 SH-J6 SH-J7 SH-J8 SH-J9 SH-J10 SH-J11 SH-J12 SH-J13 SH-J14 SH-J15 SH-J16 SH-J17 SH-J30 SH-J31 TP1 TP2 TP3 TP4 TP5 TP6 TP7 TP8 TP9 TP10 TP11 TP12 TP13 TP14 TP15 TP16 TP17 TP18 TP19 TP20 TP21 TP22 TP23 TP24 TP25 TP26 TP27 TP37 TP38 TP39 TP40 TP41 TP42 TP43 TP44 TP45 TP46 U1 Y2
component class Shunt: SH-J1 SH-J2 SH-J3 SH-J4 SH-J5 SH-J6 SH-J7 SH-J8 SH-J9 SH-J10 SH-J11 SH-J12 SH-J13 SH-J14 SH-J15 SH-J16 SH-J17 SH-J18 SH-J19 SH-J20 SH-J21 SH-J22 SH-J23 SH-J24 SH-J25 SH-J26 SH-J27 SH-J28 SH-J29 SH-J30 SH-J31
component class MD040_Motor_Driver_RevE2: 3 "   " C50 C51 C52 C53 C54 C55 C56 C57 C58 C59 C60 C61 C63 C64 C65 C66 C67 C68 C69 C70 C71 D4 D5 D6 D7 D8 D9 D10 D11 D12 D13 F1 J12 J13 J14 J15 J16 J17 J18 J19 J20 J21 J22 J23 J24 J27 Q1 R79 R80 R81 R82 R83 R84 R85 R86 R87 R88 R89 R90 R91 R92 R93 R94 R95 R96 R98 R99 R100 R101 R102 R103 R104 R105 R106 R107 R108 R109 R110 R111 R112 R113 R114 R115 R116 R117 R118 S1 SH-J18 SH-J19 SH-J20 SH-J21 SH-J22 TP28 TP29 TP30 TP31 TP32 TP34 TP35 U7
net class Power-Net: EZFET_VBUS EZFET_VCC GND MCU_3V3
component class Header: J3 J4 J5 J6 J7 J8 J9 J10 J16 J17 J18 J19 J20 J25 J26
component class MD040_ezFET_RevE2: C20 C21 C22 C23 C24 C25 C26 C27 C28 C29 C30 C31 C32 C33 C34 C35 C36 C37 C38 C39 C40 C41 C42 C43 C44 C45 C46 C47 C48 D1 D2 D3 J9 J10 J11 L1 L2 R55 R56 R57 R58 R59 R60 R61 R62 R63 R64 R65 R66 R67 R68 R69 R70 R71 R72 R73 R74 R75 R76 R77 R78 SH-J23 SH-J24 SH-J25 SH-J26 SH-J27 SH-J28 SH-J29 U2 U3 U4 U5 U6 Y1
component class Logo: Logo3
component class FiducialMark: FID1 FID2 FID3
component class AssemblyNote: ZZ1 ZZ2 ZZ3 ZZ4
component class Label: LBL1
differential pair USB_D: +USB_D_P -USB_D_N
differential pair EZFET_D: +EZFET_D_P -EZFET_D_N

## Components (designator, comment, footprint, x,y, rotation, side; value= is the part's Value field where it differs from the comment)
A1 "5012" Keystone5012 6.201,65.573 r0 top
A2 "5012" Keystone5012 3.24,62.366 r0 top
A3 "5012" Keystone5012 8.265,58.445 r0 top
A4 "5012" Keystone5012 3.595,54.96 r0 top
C1 "C1005C0G1H330J050BA" 0402 67.156,7.849 r270 top value=33pF
C2 "C1005C0G1H330J050BA" 0402 69.367,7.925 r270 top value=33pF
C3 "C1005C0G1H330J050BA" 0402 68.694,15.627 r90 top value=33pF
C4 "C1005C0G1H330J050BA" 0402 68.694,18.689 r90 top value=33pF
C5 "C1005C0G1H330J050BA" 0402 68.694,21.689 r90 top value=33pF
C6 "C1005C0G1H330J050BA" 0402 68.694,24.689 r90 top value=33pF
C7 "885012105010" 0402L 2.794,44.667 r90 top value=0.1uF
C8 "885012105010" 0402L 16.51,61.087 r270 top value=0.1uF
C9 "885012105010" 0402L 17.78,61.035 r270 top value=0.1uF
C10 "885012105010" 0402L 19.05,61.255 r270 top value=0.1uF
C11 "885012105010" 0402L 20.31,62.281 r270 top value=0.1uF
C12 "885012105010" 0402L 44.171,86.69 r270 top value=0.1uF
C13 "GRM155R61A474KE15D" 0402 15.443,38.43 r0 top value=0.47uF
C14 "T520A106M010ATE080" 3216-18 39.713,49.098 r270 top value=10uF
C15 "885012105010" 0402L 13.64,49.708 r90 top value=0.1uF
C16 "GRM155R61A104KA01D" 0402 12.446,38.379 r0 top value=0.1uF
C17 "GRM155R61A104KA01D" 0402 37.165,48.997 r270 top value=0.1uF
C18 "GRM155R61A104KA01D" 0402 22.631,60.096 r180 top value=0.1uF
C19 "C1005C0G1H330J050BA" 0402 52.221,66.256 r180 top value=33pF
C20 "C1005X5R1A475M050BC" 0402 30.922,105.581 r45 top value=4.7uF
C21 "GRM155R61A104KA01D" 0402 34.831,98.443 r315 top value=0.1uF
C22 "C1005C0G1H330J050BA" 0402 18.752,111.234 r180 top value=33pF
C23 "GRM155R71H102KA01D" 0402 12.903,114.802 r270 top value=1000pF
C24 "C1005C0G1H330J050BA" 0402 18.752,114.585 r180 top value=33pF
C25 "GRM155R61A104KA01D" 0402 20.45,107.428 r90 top value=0.1uF
C26 "GRM1555C1H100FA01D" 0402 33.393,90.475 r180 top value=10pF
C27 "GRM1555C1H100FA01D" 0402 37.354,83.972 r180 top value=10pF
C28 "GRM155R61A224KE19D" 0402 29.333,107.167 r45 top value=0.22uF
C29 "GRM155R61C474KE01" 0402 14.45,105.478 r90 top value=0.47uF
C30 "GRM155R61A224KE19D" 0402 30.132,106.367 r45 top value=0.22uF
C31 "T520A106M010ATE080" 3216-18 16.4,106.078 r90 top value=10uF
C32 "GRM155R61A104KA01D" 0402 19.39,107.428 r90 top value=0.1uF
C33 "GRM155R61A104KA01D" 0402 18.355,107.428 r90 top value=0.1uF
C34 "GRM155R61A104KA01D" 0402 27.88,94.71 r225 top value=0.1uF
C35 "885012105012" 0402 31.462,114.253 r90 top value=1uF
C36 "GRM155R61A104KA01D" 0402 32.54,114.253 r90 top value=0.1uF
C37 "GRM155R71C103KA01D" 0402 33.659,114.253 r90 top value=0.01uF
C38 "2.2uF" 0402 31.39,111.853 r90 top
C39 "GRM155R71C103KA01D" 0402 34.105,106.483 r0 top value=0.01uF
C40 "885012105012" 0402 30.216,111.853 r90 top value=1uF
C41 "885012105010" 0402L 55.88,109.372 r90 top value=0.1uF
C42 "GRM1555C1H100FA01D" 0402 36.853,107.51 r180 top value=10pF
C43 "GRM1555C1H100FA01D" 0402 39.464,107.51 r0 top value=10pF
C44 "HMK107BJ104MA-T" FP-0603-L_1_6_0_1-W_0_8_0-IPC_B 52.391,100.013 r270 top
C45 "885012105012" 0402 39.7,99.975 r270 top value=1uF
C46 "GRM21BC81E335KA73L" 0805_HV 49.568,98.525 r270 top value=3.3uF
C47 "GRM155R61A224KE19D" 0402 45.364,121.235 r0 top value=0.22uF
C48 "GRM155R61A104KA01D" 0402 35.405,114.003 r270 top value=0.1uF
C49 "C2012X7R1H105K125AB" 0805_HV 92.239,74.719 r90 top value=1uF
C50 "HMK107BJ104MA-T" FP-0603-L_1_6_0_1-W_0_8_0-IPC_B 92.146,58.232 r90 top
C51 "C2012X7R1H105K125AB" 0805_HV 103.11,56.083 r180 top value=1uF
C52 "C0603C102K1RACAUTO" FP-C0603C-CF-MFG 118.161,44.653 r90 top value="1,000 pF"
C53 "EMVY101ARA101MKE0S" FP-EMVY101ARA101MKE0S_RADIAL-MFG 92.177,98.545 r180 top value=100µF
C54 "C0603C102K1RACAUTO" FP-C0603C-CF-MFG 77.88,109.155 r180 bottom value="1,000 pF"
C55 "HMK107BJ104MA-T" FP-0603-L_1_6_0_1-W_0_8_0-IPC_B 77.813,107.164 r180 bottom
C56 "GRM21BC72A105KE01L" FP-GRM21-0_2-MFG 104.648,53.569 r180 top value=1uF
C57 "HMK107B7103MA-T" FP-0603-L_1_6_0_1-W_0_8_0-IPC_A 106.594,65.405 r0 top
C58 "HMK107B7103MA-T" FP-0603-L_1_6_0_1-W_0_8_0-IPC_A 105.588,58.014 r90 top
C59 "HMK107B7103MA-T" FP-0603-L_1_6_0_1-W_0_8_0-IPC_A 105.288,72.989 r90 top
C60 "C0603C102K1RACAUTO" FP-C0603C-CF-MFG 119.208,55.677 r90 bottom value="1,000 pF"
C61 "C0603C102K1RACAUTO" FP-C0603C-CF-MFG 117.983,65.407 r0 top value="1,000 pF"
C62 "885012105010" 0402L 72.194,64.033 r180 top value=0.1uF
C63 "0.1uF" CAPC0603(1608)100_L 89.811,74.371 r270 top value=100nF
C64 "C0603C102K1RACAUTO" FP-C0603C-CF-MFG 116.459,92.202 r315 top value="1,000 pF"
C65 "C0603C102K1RACAUTO" FP-C0603C-CF-MFG 119.151,81.966 r270 bottom value="1,000 pF"
C66 "C0603C102K1RACAUTO" FP-C0603C-CF-MFG 118.008,68.072 r0 top value="1,000 pF"
C67 "C0402C101J1HACTU" FP-C0402C101J1HAC_0402-IPC_B 120.218,37.276 r270 top
C68 "C0402C101J1HACTU" FP-C0402C101J1HAC_0402-IPC_B 120.309,29.605 r270 top
C69 "C0402C101J1HACTU" FP-C0402C101J1HAC_0402-IPC_B 120.139,22.382 r270 top
C70 "C0402C101J1HACTU" FP-C0402C101J1HAC_0402-IPC_B 120.367,14.876 r270 top
C71 "C0402C101J1HACTU" FP-C0402C101J1HAC_0402-IPC_B 107.824,7.35 r270 top
C72 "885012205031" 0402 10.913,50.974 r0 top value=0.01uF
C73 "885012205031" 0402 10.922,52.222 r180 top value=0.01uF
C74 "1.1 nF" FP-C0805C-DN-MFG 37.054,64.726 r180 top value="1,100 pF"
D1 "150060RS75000" WL-SMCW_RED 14.011,109.934 r270 top value=Red
D2 "CMP-0002894-2" WL-SMCW_GREEN 11.633,109.851 r270 top value=Green
D3 "MMDL770T1G" ONSC-SOD-323-2-477-02_V 34.768,117.704 r180 top
D4 "150060SS75000" 0603_A 77.763,116.901 r0 top
D5 "150060VS75000" WL-SMCW_GREEN 42.088,88.316 r90 top value=Green
D6 "150060VS75000" WL-SMCW_GREEN 5.844,31.707 r90 top value=Green
D7 "150060SS75000" WL-SMCW_RED 78.545,90.856 r0 top value=Red
D8 "150060VS75000" WL-SMCW_GREEN 8.888,31.708 r90 top value=Green
D9 "150060YS75000" WL-SMCW_YELLOW 12.08,31.718 r90 top value=Yellow
D10 "150060VS75000" WL-SMCW_GREEN 15.269,31.734 r90 top
D10 "150060YS75000" WL-SMCW_YELLOW 15.269,31.734 r90 top value=Yellow
D11 "150060VS75000" WL-SMCW_GREEN 18.301,31.737 r90 top
D11 "150060YS75000" WL-SMCW_YELLOW 18.301,31.737 r90 top value=Yellow
D12 "150060SS75000" WL-SMCW_RED 21.715,31.763 r90 top
D12 "150060YS75000" WL-SMCW_YELLOW 21.715,31.763 r90 top value=Yellow
D13 "BZX84J-B4V7,115" FP-SOD323F-MFG 69.013,118.813 r180 top
F1 "0463015.ER" Fuse_0463 107.645,99.39 r90 top
FID1 "Fiducial" Fiducial10-20 2,125 r0 top locked
FID2 "Fiducial" Fiducial10-20 2,2 r90 top
FID3 "Fiducial" Fiducial10-20 125,125 r0 top locked
H1 "4822" KEYSTONE_4822 6.5,6.5 r0 bottom locked
H1_Nut "9605" Keystone_9605 6.5,6.5 r0 top locked
H2 "4822" KEYSTONE_4822 120.5,6.5 r0 bottom locked
H2_Nut "9605" Keystone_9605 120.5,6.5 r0 top locked
H3 "4822" KEYSTONE_4822 120.5,120.5 r0 bottom locked
H3_Nut "9605" Keystone_9605 120.5,120.5 r0 top locked
H4 "4822" KEYSTONE_4822 6.5,120.5 r180 bottom locked
H4_Nut "9605" Keystone_9605 6.5,120.5 r0 top locked
J1 "CMP-0075613-1" Samtec_SSQ-110-03-x-D 74.09,14.439 r90 bottom
J2 "CMP-0075613-1" Samtec_SSQ-110-03-x-D 30.91,14.439 r90 bottom
J3 "Header_7x2_PEC07DAAN" CONN_PEC07DAAN 24.46,78.01 r180 top
J4 "TSM-108-01-L-DV" Samtec_TSM-108-01-x-DV 63.989,82.473 r0 top
J5 "PBC02SAAN" Sullins_PBC02SAAN 73,68.663 r0 top
J6 "PBC02SAAN" Sullins_PBC02SAAN 57.175,69.926 r270 top
J7 "PBC02SAAN" Sullins_PBC02SAAN 57.175,66.371 r270 top
J8 "TSM-108-01-L-DV" Samtec_TSM-108-01-x-DV 63.998,53.213 r0 top
J9 "61301421121" Wurth_61301421121 21.499,122.362 r270 top
J10 "PEC07DAAN" CONN_PEC07DAAN 24.689,85.979 r180 top
J11 "CMP-0055311-1" Molex_1051640001 37.741,125.432 r180 top
J12 "691256610002" FP-691256610002_HDR2-MFG 104.064,117.78 r180 top
J13 "691250610002" FP-691250610002_CONN_TERM_BLOCK2-MFG 120.776,81.539 r90 top
J14 "691250610002" FP-691250610002_CONN_TERM_BLOCK2-MFG 120.771,55.359 r90 top
J15 "D3082-05" Harwin_D3082-05 70.96,122.998 r180 top
J16 "PBC02SAAN" Sullins_PBC02SAAN 77.927,83.276 r90 top
J17 "PBC02SAAN" Sullins_PBC02SAAN 78.384,68.595 r90 top
J18 "PBC02SAAN" Sullins_PBC02SAAN 78.489,72.23 r90 top
J19 "PBC02SAAN" Sullins_PBC02SAAN 83.408,74.791 r0 top
J20 "PBC02SAAN" Sullins_PBC02SAAN 78.511,79.197 r90 top
J21 "D3082-05" Harwin_D3082-05 3.531,94.158 r90 top
J22 "D3082-05" Harwin_D3082-05 109.104,64.636 r270 top
J23 "691250610002" FP-691250610002_CONN_TERM_BLOCK2-MFG 120.777,101.321 r90 top
J24 "D3082-05" Harwin_D3082-05 113.055,65.608 r270 top
J25 "PBC02SAAN" Sullins_PBC02SAAN 64.075,69.926 r270 top
J26 "PBC02SAAN" Sullins_PBC02SAAN 69.444,68.631 r0 top
J27 "PR20203VBNN" FP-PR20203VBNN-MFG 44.704,66.091 r0 top
L1 "BLM18AG151BH1D" 0603 31.905,118.956 r270 top value="150 ohm"
L2 "BLM18AG151BH1D" 0603 39.604,117.544 r270 top value="150 ohm"
LBL1 "THT-14-423-10" Label_650x200 65.303,101.397 r0 top
LOGO1 "CAUTION HOT SURFACE" IEC_HotSurface_Small 100.584,12.929 r0 top
Logo2 "CE Mark" CE_Mark_5mm 51.232,21.738 r180 bottom
Logo3 "Texas Instruments" TI_Stacked_Overlay_Small 94.336,33.147 r0 top
Logo4 "FCC disclaimer" FCC_disclaimer 219.786,-41.005 r90 bottom
Logo5 "WEEE logo" WEEE_Minimum 51.714,13.413 r180 bottom
Logo6 "CAUTION.  READ USER GUIDE BEFORE USE" IEC_Caution_Small 52.526,14.479 r0 top
Q1 "BC846BLT1G" ONSC-SOT-23-3-318-08_V 73.763,117.538 r0 top
R1 "Resistor" 0402L 78.64,2.939 r180 top value=0
R2 "CRCW0603330KJNEA" 0603L 13.047,42.922 r270 top value=330k
R3 "CRCW0603330KJNEA" 0603L 33.47,38.3 r180 top value=330k
R4 "CH0402-10RJFPT" FP-CH0402-10RJFPT_0402-MFG 3.238,47.155 r180 top value=10
R5 "Resistor" 0402L 117.078,37.16 r270 top value=0
R6 "Resistor" 0402L 78.59,20.864 r180 top value=0
R7 "Resistor" 0402L 118.582,37.149 r270 top value=0
R8 "Resistor" 0402L 117.145,29.456 r270 top value=0
R9 "Resistor" 0402L 36.34,2.889 r180 top value=0
R10 "Resistor" 0402L 118.608,29.572 r270 top value=0
R11 "Resistor" 0402L 36.34,18.249 r180 top value=0
R12 "Resistor" 0402L 118.531,22.366 r270 top value=0
R13 "Resistor" 0402L 117.297,22.366 r270 top value=0
R14 "Resistor" 0402L 65.59,23.439 r0 top value=0
R15 "Resistor" 0402L 118.701,14.622 r270 top value=0
R16 "Resistor" 0402L 117.507,14.526 r270 top value=0
R17 "Resistor" 0402L 65.59,20.921 r0 top value=0
R18 "Resistor" 0402L 65.615,17.939 r0 top value=0
R19 "CRCW060310K0FKEA" 0603 68.762,27.991 r180 top value=10.0k
R20 "Resistor" 0402L 32.131,73.762 r180 top value=0
R21 "Resistor" 0402L 65.59,14.992 r0 top value=0
R22 "Resistor" 0402L 29.82,73.711 r0 top value=0
R23 "Resistor" 0402L 36.22,23.495 r180 top value=0
R24 "Resistor" 0402L 36.365,5.549 r180 top value=0
R25 "Resistor" 0402L 36.195,20.726 r180 top value=0
R26 "Resistor" 0402L 36.212,15.578 r180 top value=0
R27 "Resistor" 0402L 78.59,18.139 r180 top value=0
R29 "47k" RESC1005X40X25ML05T10 22.532,62.535 r180 top
R30 "Resistor" 0402L 36.271,25.806 r180 top value=0
R32 "Resistor" 0402L 36.34,8.039 r180 top value=0
R33 "Resistor" 0402L 78.59,13.189 r180 top value=0
R34 "Resistor" 0402L 36.34,10.689 r180 top value=0
R35 "CH0402-10RJFPT" FP-CH0402-10RJFPT_0402-MFG 5.856,47.155 r0 top value=10
R39 "CRCW04021K00FKED" 0402L 57.15,83.795 r0 top value=1.00k
R40 "CRCW04021K00FKED" 0402L 57.108,81.203 r0 top value=1.00k
R41 "CRCW04021K00FKED" 0402L 57.148,78.664 r0 top value=1.00k
R42 "CRCW04021K00FKED" 0402L 57.133,76.098 r0 top value=1.00k
R44 "CRCW060310K0FKEA" 0603 52.221,70.104 r180 top value=10.0k
R49 "CRCW060310K0FKEA" 0603 52.221,68.093 r0 top value=10.0k
R54 "Resistor" 0402L 17.25,71.501 r180 top value=0
R55 "RC0402FR-07220KL" 0402 18.755,113.459 r180 top value=220k
R56 "240k" RESC1005X40X25NL05T05 18.694,116.967 r180 top
R57 "CRCW040247K0JNED" 0402 14.529,114.783 r270 top value=47k
R58 "CRCW0402470RJNED" 0402 13.028,105.434 r270 top value=470
R59 "CRCW0402560RJNED" 0402 11.608,105.379 r270 top value=560
R60 "RC0402FR-07220KL" 0402 18.755,112.398 r0 top value=220k
R61 "CRCW0402150KFKED" 0402 18.752,115.63 r0 top value=150k
R62 "ERJ-2GE0R00X" 0402L 27.461,116.185 r90 top value=0
R63 "ERJ-2GE0R00X" 0402L 28.512,116.185 r90 top value=0
R64 "CRCW040210R0FKED" 0402 30.382,91.112 r225 top value=10.0
R65 "CRCW040210R0FKED" 0402 27.858,91.112 r225 top value=10.0
R66 "CRCW040210R0FKED" 0402 25.342,91.114 r225 top value=10.0
R67 "CRCW040210R0FKED" 0402 22.794,91.112 r225 top value=10.0
R68 "Resistor" 0402L 37.655,103.15 r270 top value=0
R69 "Resistor" 0603L 43.073,116.053 r0 top value=0
R70 "Resistor" 0603L 43.105,113.383 r180 top value=0
R71 "CRCW040227R0JNED" 0402 43.012,105.745 r0 top value=27
R72 "CRCW040227R0JNED" 0402 37.616,112.435 r270 top value=27
R73 "CRCW040227R0JNED" 0402 43.028,107.344 r0 top value=27
R74 "0" RESC1005X40X25NL05T05 37.186,101.469 r180 top
R75 "CRCW040227R0JNED" 0402 38.846,112.435 r270 top value=27
R76 "CRCW04021K40FKED" 0402 32.458,102.675 r315 top value=1.40k
R77 "CRCW04021M00JNED" 0402 33.181,103.438 r135 top value=1.0Meg
R78 "CRCW040233K0JNED" 0402 45.364,122.834 r180 top value=33k
R79 "ERJ-2RKF3301X" 0402L 78.588,86.106 r0 top value=3.30k
R80 "ERJ-2RKF3301X" 0402L 79.045,65.684 r0 top value=3.30k
R81 "ERJ-2RKF3301X" 0402L 79.35,75.106 r0 top value=3.30k
R82 "ERJ-2RKF3301X" 0402L 79.332,76.286 r0 top value=3.30k
R83 "RC0603JR-0710KL" 0603L 90.907,70.968 r90 top value=10k
R84 "CRCW04020000Z0EDHP" 0402 76.225,86.131 r0 top value=0
R85 "CRCW04020000Z0EDHP" 0402 76.765,65.684 r0 top value=0
R86 "CRCW04020000Z0EDHP" 0402 76.987,75.082 r0 top value=0
R87 "CRCW04020000Z0EDHP" 0402 77.013,76.286 r0 top value=0
R88 "RC0603JR-0710KL" 0603L 88.875,70.948 r90 top value=10k
R89 "CRCW060386K6FKEA" 0603L 122.352,40.244 r90 top value=86.6k
R90 "CRCW060386K6FKEA" 0603L 122.129,32.982 r90 top value=86.6k
R91 "CRCW060386K6FKEA" 0603L 122.389,25.632 r90 top value=86.6k
R92 "CRCW060386K6FKEA" 0603L 122.404,17.755 r90 top value=86.6k
R93 "CRCW06034K99FKEA" 0603L 122.352,37.363 r90 top value=4.99k
R94 "CRCW06034K99FKEA" 0603L 122.152,29.332 r90 top value=4.99k
R95 "CRCW06034K99FKEA" 0603L 122.389,22.382 r90 top value=4.99k
R96 "CRCW06034K99FKEA" 0603L 122.377,14.656 r90 top value=4.99k
R97 "CRCW040247K0JNED" 0402 77.763,118.591 r0 top value=47k
R98 "RT0603DRE0797K6L" 0603 109.855,10.302 r90 top value=97.6k
R99 "RC0603JR-0710KL" 0603L 5.359,34.112 r180 top value=10k
R100 "RC0603JR-0710KL" 0603L 5.359,35.662 r180 top value=10k
R101 "RC0603JR-0710KL" 0603L 5.385,38.379 r180 top value=10k
R102 "RC0603JR-0710KL" 0603L 31.66,64.785 r270 top value=10k
R103 "RC0603JR-0710KL" 0603L 29.388,64.784 r270 top value=10k
R104 "CRCW06034K99FKEA" 0603L 109.861,7.421 r90 top value=4.99k
R105 "RC0603JR-0710KL" 0603L 2.438,34.036 r180 top value=10k
R106 "RC0603JR-0710KL" 0603L 2.438,35.632 r180 top value=10k
R107 "RC0603JR-0710KL" 0603L 2.489,38.329 r180 top value=10k
R108 "RC0603JR-0710KL" 0603L 31.66,61.905 r270 top value=10k
R109 "RC0603JR-0710KL" 0603L 29.388,61.904 r270 top value=10k
R110 "RC0603FR-07560RL" 0603 42.06,84.864 r90 top value=560
R111 "CMP-0025785-4" 0603L 15.269,28.393 r90 top value=330
R112 "CMP-0025785-4" 0603L 75.26,90.856 r0 top value=330
R113 "CMP-0025785-4" 0603L 8.888,28.296 r90 top value=330
R114 "CMP-0025785-4" 0603L 5.831,28.245 r90 top value=330
R115 "CMP-0025785-4" 0603L 12.083,28.278 r90 top value=330
R116 "CMP-0025785-4" 0603L 18.318,28.386 r90 top value=330
R117 "CMP-0025785-4" 0603L 21.69,28.402 r90 top value=330
R118 "RC0603FR-07470RL" 0603 68.735,116.551 r0 top value=470
S1 "FSM4JSMA" SW_FSM4JSMA 47.701,60.122 r90 top
SH-J1 "SNT-100-BK-G" SNT-100-BK-G 135.89,110.896 r90 top value=1x2
SH-J2 "SNT-100-BK-G" SNT-100-BK-G 143.281,110.719 r90 top value=1x2
SH-J3 "SNT-100-BK-G" SNT-100-BK-G 151.241,110.75 r90 top value=1x2
SH-J4 "SNT-100-BK-G" SNT-100-BK-G 135.5,99.25 r90 top value=1x2
SH-J5 "SNT-100-BK-G" SNT-100-BK-G 143,98.5 r90 top value=1x2
SH-J6 "SNT-100-BK-G" SNT-100-BK-G 151.359,98.867 r90 top value=1x2
SH-J7 "SNT-100-BK-G" SNT-100-BK-G 135.382,88.011 r90 top value=1x2
SH-J8 "SNT-100-BK-G" SNT-100-BK-G 142.951,88.494 r90 top value=1x2
SH-J9 "SNT-100-BK-G" SNT-100-BK-G 151.181,88.341 r90 top value=1x2
SH-J10 "SNT-100-BK-G" SNT-100-BK-G 136,76.5 r90 top value=1x2
SH-J11 "SNT-100-BK-G" SNT-100-BK-G 143.129,76.5 r90 top value=1x2
SH-J12 "SNT-100-BK-G" SNT-100-BK-G 151.359,76.5 r90 top value=1x2
SH-J13 "SNT-100-BK-G" SNT-100-BK-G 135.75,65.5 r90 top value=1x2
SH-J14 "SNT-100-BK-G" SNT-100-BK-G 143.281,65.634 r90 top value=1x2
SH-J15 "SNT-100-BK-G" SNT-100-BK-G 151.359,65.964 r90 top value=1x2
SH-J16 "SNT-100-BK-G" SNT-100-BK-G 136,55.25 r90 top value=1x2
SH-J17 "SNT-100-BK-G" SNT-100-BK-G 143.612,55.25 r90 top value=1x2
SH-J18 "SNT-100-BK-G" SNT-100-BK-G 151.511,55.25 r90 top value=1x2
SH-J19 "SNT-100-BK-G" SNT-100-BK-G 136,44 r90 top value=1x2
SH-J20 "SNT-100-BK-G" SNT-100-BK-G 143.789,44.399 r90 top value=1x2
SH-J21 "SNT-100-BK-G" SNT-100-BK-G 151.511,44.552 r90 top value=1x2
SH-J22 "SNT-100-BK-G" SNT-100-BK-G 135.75,33.75 r90 top value=1x2
SH-J23 "60900213421" Wurth_60900213421 142.748,2.337 r90 top
SH-J24 "60900213421" Wurth_60900213421 149.352,2.337 r90 top
SH-J25 "60900213421" Wurth_60900213421 155.956,2.337 r90 top
SH-J26 "60900213421" Wurth_60900213421 162.56,2.337 r90 top
SH-J27 "60900213421" Wurth_60900213421 43.477,66.089 r180 top
SH-J28 "60900213421" Wurth_60900213421 143.866,32.817 r90 top
SH-J29 "60900213421" Wurth_60900213421 136.119,2.337 r90 top
SH-J30 "SNT-100-BK-G" SNT-100-BK-G 169.291,9.779 r90 top value=1x2
SH-J31 "SNT-100-BK-G" SNT-100-BK-G 162.56,9.881 r90 top value=1x2
TP1 "TP_H0.45P0.75" TP_H045P075 8.071,44.737 r90 top
TP2 "TP_H0.45P0.75" TP_H045P075 9.872,43.975 r90 top
TP3 "TP_H0.45P0.75" TP_H045P075 8.133,42.748 r90 top
TP4 "TP_H0.45P0.75" TP_H045P075 9.906,41.808 r90 top
TP5 "TP_H0.45P0.75" TP_H045P075 8.122,40.75 r90 top
TP6 "TP_H0.45P0.75" TP_H045P075 26.226,38.625 r90 top
TP7 "TP_H0.45P0.75" TP_H045P075 27.889,36.987 r90 top
TP8 "TP_H0.45P0.75" TP_H045P075 27.838,38.6 r90 top
TP9 "TP_H0.45P0.75" TP_H045P075 29.667,38.575 r90 top
TP10 "TP_H0.45P0.75" TP_H045P075 34.239,45.558 r90 top
TP11 "TP_H0.45P0.75" TP_H045P075 34.812,47.208 r90 top
TP12 "TP_H0.45P0.75" TP_H045P075 33.179,47.298 r90 top
TP13 "5012" Keystone5012 14.326,67.92 r0 top
TP14 "5012" Keystone5012 9.627,47.828 r0 top
TP15 "5012" Keystone5012 9.093,69.25 r0 top
TP16 "5012" Keystone5012 25.832,63.602 r0 top
TP17 "5012" Keystone5012 10.316,65.484 r0 top
TP18 "TP_H0.45P0.75" TP_H045P075 36.359,51.856 r90 top
TP19 "TP_H0.45P0.75" TP_H045P075 34.747,52.363 r90 top
TP20 "TP_H0.45P0.75" TP_H045P075 36.373,53.468 r90 top
TP21 "TP_H0.45P0.75" TP_H045P075 34.747,53.975 r90 top
TP22 "TP_H0.45P0.75" TP_H045P075 36.424,55.081 r90 top
TP23 "TP_H0.45P0.75" TP_H045P075 34.747,55.887 r90 top
TP24 "TP_H0.45P0.75" TP_H045P075 36.373,56.693 r90 top
TP25 "5011" Keystone5011 2.311,29.845 r0 top
TP26 "TP_H0.45P0.75" TP_H045P075 34.714,57.5 r90 top
TP27 "5010" Keystone5010 42.062,93.37 r0 top
TP28 "5010" Keystone5010 83.769,84.455 r0 top
TP29 "5011" Keystone5011 91.008,48.336 r0 top
TP30 "5010" Keystone5010 81.75,120 r180 top
TP31 "5015" Testpoint_Keystone_Miniature 122.477,45.136 r270 top
TP32 "5015" Testpoint_Keystone_Miniature 122.53,65.395 r90 top
TP34 "5015" Testpoint_Keystone_Miniature 122.631,91.364 r90 top
TP35 "5015" Testpoint_Keystone_Miniature 122.479,71.247 r90 top
TP37 "5012" Keystone5012 89.165,8.661 r0 top
TP38 "5012" Keystone5012 84.346,9.601 r0 top
TP39 "5012" Keystone5012 89.165,13.246 r0 top
TP40 "5012" Keystone5012 84.318,14.275 r0 top
TP41 "5012" Keystone5012 89.073,17.805 r0 top
TP42 "5012" Keystone5012 84.346,19.38 r0 top
TP43 "5012" Keystone5012 89.101,22.327 r0 top
TP44 "5012" Keystone5012 84.455,24.359 r0 top
TP45 "5012" Keystone5012 89.129,26.848 r0 top
TP46 "5012" Keystone5012 17.501,5.537 r0 top
U1 "MSP430F5338IPZ" PZT0100A_N 23.572,49.35 r0 top
U2 "CMP-0039269-4" RGC0064B 23.366,101.605 r315 top
U3 "TPS73533DRBR" DRB0008A 35.07,110.23 r90 top
U4 "FT232RL" SSOP28_N 49.918,111.735 r0 top
U5 "TPS7A4333DGQ" DGQ0010E-MFG 44.797,99.853 r0 top
U6 "TPD2E001DRYR" DRY0006A 37.509,118.633 r90 top
U7 "DRV8452DDWR" DDW0044E-MFG 98.136,65.363 r180 top
Y1 "CSTNR4M00GH5L000R0" MuRata_CSTNR 27.825,110.507 r135 top
Y2 "MS3V-T1R 32.768KHZ +/-20PPM 12.5PF" XTAL_MS3V-T1R 5.724,51.522 r180 top
ZZ1 "This Assembly Note is for PCB labels only" AssemblyNoteLabel 5,146.25 r0 top
ZZ2 "These assemblies are ESD sensitive, ESD precautions shall be observed." AssemblyNote 5,143.25 r0 top
ZZ3 "These assemblies must be clean and free from flux and all contaminants. Use of no clean flux is not acceptable." AssemblyNote 5,140 r0 top
ZZ4 "These assemblies must comply with workmanship standards IPC-A-610 Class 2, unless otherwise specified." AssemblyNote 5,136.25 r0 top

## Footprints (in the part's own frame and the unit in brackets; to place one, negate y for a bottom-side part, rotate by r counter-clockwise, add the part's x,y. Pads: shape width x height; smd on the part's side, far side on the other; paste and mask are expansions set on the pad)
0402 [mm] "0402 from SM-752 data"
  rect 0.8x0.6 smd: 1(-0.6,0) 2(0.6,0)
  silkscreen extent -1.22,-0.52 1.22,0.52, body extent -0.55,-0.3 0.55,0.3, height 0.6
0402L [mm] "0402 from SM-752 data"
  rect 0.6x0.5 smd: 1(-0.5,0) 2(0.5,0)
  body extent -0.55,-0.3 0.55,0.3, height 0.6
0603 [mm] "0603 from SM-752 data"
  rect 1x0.95 smd: 1(-0.8,0) 2(0.8,0)
  silkscreen extent -1.52,-0.69 1.52,0.69, body extent -0.87,-0.47 0.87,0.47, height 1
0603_A [mm] "Chip LED, 2-Leads, Body 1.6x0.8mm, IPC Medium Density"
  rect 0.8x0.8 smd: 1(-0.8,0) 2(0.8,0)
  silkscreen extent -1.5,-0.3 -1.5,0.3, body extent -0.8,-0.4 0.8,0.4, height 0.7
0603L [mm] "0603 from SM-752 data"
  rect 0.8x0.85 smd: 1(-0.7,0) 2(0.7,0)
  silkscreen extent -0.07,-0.33 0.07,0.33, body extent -0.87,-0.47 0.87,0.47, height 1
0805_HV [mil] "0805 with 30mil clearance between pads"
  rect 50x63 smd: 1(-40,0) 2(40,0)
  silkscreen extent -74,-40 74,40, body extent -43,-29 43,29, height 57
3216-18 [mm] "Based on AVX recommendation in http://www.avx.com/download/software/literature/AVX-Footprint-Library.pdf"
  rrect7% 1.4x1.8 smd: 1(-1.3,0) 2(1.3,0)
  silkscreen extent -1.9,-1.12 0.8,1.12, body extent -1.7,-0.9 1.7,0.9, height 1.82
AssemblyNote [mm] "Assembly Note"
AssemblyNoteLabel [mm] "Assembly Note for PCB Labels"
CAPC0603(1608)100_L [mm] "Chip Capacitor, Body 1.6x0.8mm, Height 1.0mm, IPC High Density"
  rect 0.7x0.9 smd: 1(-0.7,0) 2(0.7,0)
  silkscreen extent -0.05,-0.35 0.05,0.35, body extent -0.87,-0.47 0.88,0.48, height 1
CE_Mark_5mm [mm] "Minimum text height for CE Mark"
  silkscreen extent -3.5,-2.5 3.5,2.5
CONN_PEC07DAAN [mm] "SULLINS"
  rect 1.65x1.65 hole 1.016 mask+0: 1(-7.62,-1.27)
  round 1.65 hole 1.016 mask+0: 2(-7.62,1.27) 3(-5.08,-1.27) 4(-5.08,1.27) 5(-2.54,-1.27) 6(-2.54,1.27) 7(0,-1.27) 8(0,1.27) 9(2.54,-1.27) 10(2.54,1.27) 11(5.08,-1.27) 12(5.08,1.27) 13(7.62,-1.27) 14(7.62,1.27)
  silkscreen extent -9.99,-2.6 8.89,2.54, body extent -8.95,-2.6 8.95,2.6, height 8.38
DDW0044E-MFG [mm]
  rrect25% 1.45x0.4 smd paste+0 mask+0: 1(-3.75,6.668) 2(-3.75,6.033) 3(-3.75,5.398) 4(-3.75,4.763) 5(-3.75,4.128) 6(-3.75,3.493) 7(-3.75,2.858) 8(-3.75,2.223) 9(-3.75,1.588) 10(-3.75,0.953) 11(-3.75,0.318) 12(-3.75,-0.318) 13(-3.75,-0.953) 14(-3.75,-1.588) 15(-3.75,-2.223) 16(-3.75,-2.858) 17(-3.75,-3.493) 18(-3.75,-4.128) 19(-3.75,-4.763) 20(-3.75,-5.398) 21(-3.75,-6.033) 22(-3.75,-6.667) 23(3.75,-6.667) 24(3.75,-6.032) 25(3.75,-5.397) 26(3.75,-4.762) 27(3.75,-4.127) 28(3.75,-3.492) 29(3.75,-2.857) 30(3.75,-2.222) 31(3.75,-1.587) 32(3.75,-0.952) 33(3.75,-0.317) 34(3.75,0.318) 35(3.75,0.953) 36(3.75,1.588) 37(3.75,2.223) 38(3.75,2.858) 39(3.75,3.493) 40(3.75,4.128) 41(3.75,4.763) 42(3.75,5.398) 43(3.75,6.033) 44(3.75,6.668)
  rrect2% 5.2x14 smd paste-1000 mask-1000: 45(0,0)
  silkscreen extent -5.16,-7.4 3.1,7.4, body extent -4.57,-7.3 4.57,7.3, height 0.25
DGQ0010E-MFG [mm]
  rrect33% 1.45x0.3 smd paste+0 mask+0: 1(-2.2,1) 2(-2.2,0.5) 3(-2.2,0) 4(-2.2,-0.5) 5(-2.2,-1) 6(2.2,-1) 7(2.2,-0.5) 8(2.2,0) 9(2.2,0.5) 10(2.2,1)
  rrect5% 2.2x3.1 smd paste-1000 mask-1000: 11(0,0)
  silkscreen extent -3.6,-1.65 1.65,1.65, body extent -3.03,-1.8 3.03,1.8, height 0.25
DRB0008A [mm] "VSON-8"
  rrect32% 0.6x0.31 smd: 1(-1.4,0.975) 2(-1.4,0.325) 3(-1.4,-0.325) 4(-1.4,-0.975) 5(1.4,-0.975) 6(1.4,-0.325) 7(1.4,0.325) 8(1.4,0.975)
  rrect7% 1.5x1.75 smd paste-0.75: 9(0,0)
  Top Layer region: -0.7,-0.875 -0.49,-0.875 -0.471,-0.879 -0.455,-0.89 -0.444,-0.906 -0.44,-0.925 -0.44,-0.925 -0.44,-1.65 -0.436,-1.669 -0.425,-1.685 -0.409,-1.696 -0.39,-1.7 -0.39,-1.7 -0.26,-1.7 -0.241,-1.696 -0.225,-1.685 -0.214,-1.669 -0.21,-1.65 -0.21,-1.65 -0.21,-0.925 -0.206,-0.906 -0.195,-0.89 -0.179,-0.879 -0.16,-0.875 -0.16,-0.875 0.16,-0.875 0.179,-0.879 0.195,-0.89 0.206,-0.906 0.21,-0.925 0.21,-0.925 0.21,-1.65 0.21,-1.65 0.214,-1.669 0.225,-1.685 0.241,-1.696 0.26,-1.7 0.26,-1.7 0.39,-1.7 0.409,-1.696 0.425,-1.685 0.436,-1.669 0.44,-1.65 0.44,-1.65 0.44,-0.925 0.444,-0.906 0.455,-0.89 0.471,-0.879 0.49,-0.875 0.49,-0.875 0.7,-0.875 0.719,-0.871 0.735,-0.86 0.746,-0.844 0.75,-0.825 0.75,-0.825 0.75,0.825 0.746,0.844 0.735,0.86 0.719,0.871 0.7,0.875 0.7,0.875 0.49,0.875 0.471,0.879 0.455,0.89 0.444,0.906 0.44,0.925 0.44,0.925 0.44,1.65 0.436,1.669 0.425,1.685 0.409,1.696 0.39,1.7 0.39,1.7 0.26,1.7 0.241,1.696 0.225,1.685 0.214,1.669 0.21,1.65 0.21,1.65 0.21,1.65 0.21,0.925 0.206,0.906 0.195,0.89 0.179,0.879 0.16,0.875 0.16,0.875 -0.16,0.875 -0.179,0.879 -0.195,0.89 -0.206,0.906 -0.21,0.925 -0.21,0.925 -0.21,1.65 -0.214,1.669 -0.225,1.685 -0.241,1.696 -0.26,1.7 -0.26,1.7 -0.39,1.7 -0.409,1.696 -0.425,1.685 -0.436,1.669 -0.44,1.65 -0.44,1.65 -0.44,0.925 -0.444,0.906 -0.455,0.89 -0.471,0.879 -0.49,0.875 -0.49,0.875 -0.7,0.875 -0.719,0.871 -0.735,0.86 -0.746,0.844 -0.75,0.825 -0.75,0.825 -0.75,-0.825 -0.746,-0.844 -0.735,-0.86 -0.719,-0.871 -0.7,-0.875
  silkscreen extent -1.73,-1.73 1.73,1.73, body extent -1.5,-1.5 1.5,1.5, height 0.77
DRY0006A [mm] "USON-6"
  rrect67% 0.45x0.3 smd paste-0.05 mask-0.05: 1(-0.275,0.5)
  rrect67% 0.4x0.3 smd paste-0.05 mask-0.05: 2(-0.3,0) 3(-0.3,-0.5) 4(0.3,-0.5) 5(0.3,0) 6(0.3,0.5)
  body extent -0.5,-0.72 0.5,0.73, height 0.58
FCC_disclaimer [mm]
Fiducial10-20 [mm]
  round 1 smd mask+0.5: 1(0,0)
  Top Layer keep-out circle w1.178: c0,0 r0.5
FP-0603-L_1_6_0_1-W_0_8_0-IPC_A [mm]
  rect 1.258x1.012 smd paste+0 mask+0: 1(-0.777,0) 2(0.777,0)
  silkscreen extent -1.41,-0.91 1.41,0.91, body extent -1.91,-1.01 1.91,1.01, height 0.25
FP-0603-L_1_6_0_1-W_0_8_0-IPC_B [mm]
  rect 1.058x0.912 smd paste+0 mask+0: 1(-0.677,0) 2(0.677,0)
  silkscreen extent -1.21,-0.86 1.21,0.86, body extent -1.46,-0.71 1.46,0.71, height 0.25
FP-691250610002_CONN_TERM_BLOCK2-MFG [mm]
  rrect4% 2.3x2.3 hole 1.5 paste-1000 mask+0: 1(-2.875,1.65)
  round 2.3 hole 1.5 paste-1000 mask+0: 2(3.475,1.65)
  silkscreen extent -6.85,-6.9 6.85,6.3, body extent -6.95,-6.4 6.95,6.4, height 0.25
FP-691256610002_HDR2-MFG [mm]
  rrect4% 2.45x2.45 hole 1.6 paste-1000 mask+0: 1(-5.08,7.55)
  round 2.45 hole 1.6 paste-1000 mask+0: 1(-5.08,-2.61) 2(5.08,7.55) 2(5.08,-2.61)
  silkscreen extent -11,-9.2 10.21,9.2, body extent -10.31,-9.3 10.31,9.3, height 0.25
FP-C0402C101J1HAC_0402-IPC_B [mm]
  rrect17% 0.665x0.572 smd paste+0 mask+0: 1(-0.404,0) 2(0.404,0)
  body extent -0.89,-0.44 0.89,0.44, height 0.25
FP-C0603C-CF-MFG [mm]
  rect 0.75x0.9 smd paste+0 mask+0: 1(-0.6,0) 2(0.6,0)
  silkscreen extent -0.87,-0.85 0.88,0.85, body extent -1.2,-0.6 1.2,0.6, height 0.25
FP-C0805C-DN-MFG [mm]
  rect 0.95x1.35 smd paste+0 mask+0: 1(-0.75,0) 2(0.75,0)
  silkscreen extent -1.1,-1.07 1.1,1.07, body extent -1.4,-0.85 1.4,0.85, height 0.25
FP-CH0402-10RJFPT_0402-MFG [mm]
  rrect20% 0.5x0.65 smd paste+0 mask+0: 1(-0.45,0) 2(0.45,0)
  silkscreen extent -0.8,-0.7 0.8,0.7, body extent -0.8,-0.45 0.8,0.45, height 0.25
FP-EMVY101ARA101MKE0S_RADIAL-MFG [mm]
  rrect4% 5.7x2.5 smd paste+0 mask+0: 1(-4.85,0) 2(4.85,0)
  silkscreen extent -8.37,-6.6 6.6,6.6, body extent -7.95,-6.85 7.95,6.85, height 0.25
FP-GRM21-0_2-MFG [mm]
  rect 0.7x1.3 smd paste+0 mask+0: 1(-0.95,0) 2(0.95,0)
  silkscreen extent -0.23,-0.72 0.23,0.72, body extent -1.4,-0.82 1.4,0.82, height 0.25
FP-PR20203VBNN-MFG [mm]
  rect 1.57x1.57 hole 1.02 paste-1000 mask+0: 1(-2.54,0)
  round 1.57 hole 1.02 paste-1000 mask+0: 2(0,0) 3(2.54,0)
  silkscreen extent -4.7,-1.25 3.81,1.25, body extent -3.91,-1.35 3.91,1.35, height 0.25
FP-SOD323F-MFG [mm]
  rect 0.6x0.6 smd paste-1000 mask+0: 1(-1.1,0) 2(1.1,0)
  silkscreen extent -2.1,-0.67 0.43,0.67, body extent -1.53,-0.82 1.53,0.82, height 0.25
Fuse_0463 [mm] "SMD, 2-Leads, Body 10.1x3.12mm"
  rrect3% 3.25x3.43 smd: 1(-4.675,0) 2(4.675,0)
  silkscreen extent -2.6,-1.5 2.6,1.5, body extent -5.05,-1.56 5.05,1.56, height 3.12
Harwin_D3082-05 [mm] "Shorting Plug, 10.16mm spacing, TH"
  round 1.8 hole 1.3: 1(-5.08,0) 2(5.08,0)
  silkscreen extent -3.9,-0.53 3.9,0.53, body extent -5.6,-0.52 5.61,0.52, height 6.63
IEC_Caution_Small [mm]
  silkscreen extent -2.72,-2.36 2.72,2.35
IEC_HotSurface_Small [mm]
  silkscreen extent -2.72,-2.36 2.72,2.35
Keystone5010 [mil] "Keystone Multipurpose loops"
  round 87 hole 63: 1(0,0)
  silkscreen extent -70,-70 70,70, body extent -63,-63 63,62, height 319
Keystone5011 [mil] "Keystone Multipurpose loops"
  round 87 hole 63: 1(0,0)
  silkscreen extent -70,-70 70,70, body extent -63,-63 63,62, height 319
Keystone5012 [mil] "Keystone Multipurpose loops"
  round 87 hole 63: 1(0,0)
  silkscreen extent -70,-70 70,70, body extent -63,-63 63,62, height 319
KEYSTONE_4822 [mil] "HEX NYLON STANDOFF 6-32, M-F"
  round 1 on Mech4: 0(0,0)
  body extent -144,-125 144,125, height 1251
Keystone_9605 [mm] "Hex Nut,4-40 Thread, 250\" Head Dia"
  body extent -3.67,-3.17 3.67,3.18, height 2.54
Label_650x200 [mil] "Thermal Transfer Label"
  round 1 on Mech13: 0(0,0)
  silkscreen extent -325,-100 325,100, body extent -325,-100 325,100, height 1
Molex_1051640001 [mm] "Receptacle, USB 2.0, Micro B, 5 Pos, 0.65mm Pitch, R/A, SMT"
  rrect22% 0.45x1.38 smd: 1(1.3,4.11) 2(0.65,4.11) 3(0,4.11) 4(-0.65,4.11) 5(-1.3,4.11)
  rrect7% 1.475x2.1 smd: 6(-2.462,3.75) 11(2.462,3.75)
  rrect100% 1.4x2.1 hole 0.6 slot 1.3 at 90 deg: 7(-3.95,1.45) 10(3.95,1.45)
  rrect7% 1.375x1.9 smd: 8(-0.938,1.45) 9(0.938,1.45)
  silkscreen extent 1.2,5.1 1.4,5.4, body extent -4.1,-0.7 4.1,4.47, height 2.45
MuRata_CSTNR [mm] "SMD, 3-Leads, Body 4.5x2mm, Pitch 1.5mm"
  rrect25% 0.4x2.6 smd: 1(-1.5,0) 2(0,0) 3(1.5,0)
  body extent -2.3,-1.05 2.3,1.05, height 1.2
ONSC-SOD-323-2-477-02_V [mm] "SOD, 2-Leads, Body 1.7x1.25mm"
  rect 0.63x0.83 smd: 1(-1.115,0) 2(1.115,0)
  silkscreen extent -1.24,-0.67 0.4,1.09, body extent -0.85,-0.63 0.85,0.63, height 1.06
ONSC-SOT-23-3-318-08_V [mm] "SOT23, 3-Leads, Body 2.92x1.3mm, Pitch 0.95mm"
  rect 0.9x0.8 smd: 1(-1,0.95) 2(-1,-0.95) 3(1,0)
  silkscreen extent -1.12,-1.46 0.65,2.02, body extent -0.65,-1.46 0.65,1.46, height 1.11
PZT0100A_N [mm] "QFP, 100-Leads, Body 14x14mm, Pitch 0.50mm, IPC Medium Density"
  oval 1.45x0.3 smd: 1(-7.725,6) 2(-7.725,5.5) 3(-7.725,5) 4(-7.725,4.5) 5(-7.725,4) 6(-7.725,3.5) 7(-7.725,3) 8(-7.725,2.5) 9(-7.725,2) 10(-7.725,1.5) 11(-7.725,1) 12(-7.725,0.5) 13(-7.725,0) 14(-7.725,-0.5) 15(-7.725,-1) 16(-7.725,-1.5) 17(-7.725,-2) 18(-7.725,-2.5) 19(-7.725,-3) 20(-7.725,-3.5) 21(-7.725,-4) 22(-7.725,-4.5) 23(-7.725,-5) 24(-7.725,-5.5) 25(-7.725,-6) 51(7.725,-6) 52(7.725,-5.5) 53(7.725,-5) 54(7.725,-4.5) 55(7.725,-4) 56(7.725,-3.5) 57(7.725,-3) 58(7.725,-2.5) 59(7.725,-2) 60(7.725,-1.5) 61(7.725,-1) 62(7.725,-0.5) 63(7.725,0) 64(7.725,0.5) 65(7.725,1) 66(7.725,1.5) 67(7.725,2) 68(7.725,2.5) 69(7.725,3) 70(7.725,3.5) 71(7.725,4) 72(7.725,4.5) 73(7.725,5) 74(7.725,5.5) 75(7.725,6)
  oval 0.3x1.45 smd: 26(-6,-7.725) 27(-5.5,-7.725) 28(-5,-7.725) 29(-4.5,-7.725) 30(-4,-7.725) 31(-3.5,-7.725) 32(-3,-7.725) 33(-2.5,-7.725) 34(-2,-7.725) 35(-1.5,-7.725) 36(-1,-7.725) 37(-0.5,-7.725) 38(0,-7.725) 39(0.5,-7.725) 40(1,-7.725) 41(1.5,-7.725) 42(2,-7.725) 43(2.5,-7.725) 44(3,-7.725) 45(3.5,-7.725) 46(4,-7.725) 47(4.5,-7.725) 48(5,-7.725) 49(5.5,-7.725) 50(6,-7.725) 76(6,7.725) 77(5.5,7.725) 78(5,7.725) 79(4.5,7.725) 80(4,7.725) 81(3.5,7.725) 82(3,7.725) 83(2.5,7.725) 84(2,7.725) 85(1.5,7.725) 86(1,7.725) 87(0.5,7.725) 88(0,7.725) 89(-0.5,7.725) 90(-1,7.725) 91(-1.5,7.725) 92(-2,7.725) 93(-2.5,7.725) 94(-3,7.725) 95(-3.5,7.725) 96(-4,7.725) 97(-4.5,7.725) 98(-5,7.725) 99(-5.5,7.725) 100(-6,7.725)
  silkscreen extent -8.1,-8.2 8.1,8.2, body extent -8.01,-8.01 8.01,8.01, height 1.6
RESC1005X40X25ML05T10 [mm] "Chip Resistor, 2-Leads, Body 1.00x0.50mm, IPC Low Density"
  rect 0.7x0.65 smd: 1(-0.475,0) 2(0.475,0)
  body extent -0.53,-0.27 0.53,0.28, height 0.4
RESC1005X40X25NL05T05 [mm] "Chip Resistor, 2-Leads, Body 1.05x0.55mm, IPC Medium Density"
  rect 0.55x0.55 smd: 1(-0.45,0) 2(0.45,0)
  body extent -0.53,-0.28 0.53,0.28, height 0.4
RGC0064B [mm] "VQFN-64"
  rrect42% 0.6x0.24 smd mask+0.07: 1(-4.4,3.75) 2(-4.4,3.25) 3(-4.4,2.75) 4(-4.4,2.25) 5(-4.4,1.75) 6(-4.4,1.25) 7(-4.4,0.75) 8(-4.4,0.25) 9(-4.4,-0.25) 10(-4.4,-0.75) 11(-4.4,-1.25) 12(-4.4,-1.75) 13(-4.4,-2.25) 14(-4.4,-2.75) 15(-4.4,-3.25) 16(-4.4,-3.75) 33(4.4,-3.75) 34(4.4,-3.25) 35(4.4,-2.75) 36(4.4,-2.25) 37(4.4,-1.75) 38(4.4,-1.25) 39(4.4,-0.75) 40(4.4,-0.25) 41(4.4,0.25) 42(4.4,0.75) 43(4.4,1.25) 44(4.4,1.75) 45(4.4,2.25) 46(4.4,2.75) 47(4.4,3.25) 48(4.4,3.75)
  rrect42% 0.24x0.6 smd mask+0.07: 17(-3.75,-4.4) 18(-3.25,-4.4) 19(-2.75,-4.4) 20(-2.25,-4.4) 21(-1.75,-4.4) 22(-1.25,-4.4) 23(-0.75,-4.4) 24(-0.25,-4.4) 25(0.25,-4.4) 26(0.75,-4.4) 27(1.25,-4.4) 28(1.75,-4.4) 29(2.25,-4.4) 30(2.75,-4.4) 31(3.25,-4.4) 32(3.75,-4.4) 49(3.75,4.4) 50(3.25,4.4) 51(2.75,4.4) 52(2.25,4.4) 53(1.75,4.4) 54(1.25,4.4) 55(0.75,4.4) 56(0.25,4.4) 57(-0.25,4.4) 58(-0.75,4.4) 59(-1.25,4.4) 60(-1.75,4.4) 61(-2.25,4.4) 62(-2.75,4.4) 63(-3.25,4.4) 64(-3.75,4.4)
  rrect2% 4.25x4.25 smd paste-2.112: 65(0,0)
  body extent -4.5,-4.5 4.5,4.5, height 1
Samtec_SSQ-110-03-x-D [mm] "Receptacle, 2.54mm, 10x2, TH"
  rect 1.55x1.55 hole 1.02: 1(-11.43,1.27)
  round 1.55 hole 1.02: 2(-11.43,-1.27) 3(-8.89,1.27) 4(-8.89,-1.27) 5(-6.35,1.27) 6(-6.35,-1.27) 7(-3.81,1.27) 8(-3.81,-1.27) 9(-1.27,1.27) 10(-1.27,-1.27) 11(1.27,1.27) 12(1.27,-1.27) 13(3.81,1.27) 14(3.81,-1.27) 15(6.35,1.27) 16(6.35,-1.27) 17(8.89,1.27) 18(8.89,-1.27) 19(11.43,1.27) 20(11.43,-1.27)
  silkscreen extent -12.95,-2.48 12.95,3, body extent -12.95,-2.48 12.95,2.48, height 8.51
Samtec_TSM-108-01-x-DV [mm] "Header, 2.54mm, 8x2, SMT"
  rect 3.68x1.27 smd: 1(-2.475,8.89) 2(2.475,8.89) 3(-2.475,6.35) 4(2.475,6.35) 5(-2.475,3.81) 6(2.475,3.81) 7(-2.475,1.27) 8(2.475,1.27) 9(-2.475,-1.27) 10(2.475,-1.27) 11(-2.475,-3.81) 12(2.475,-3.81) 13(-2.475,-6.35) 14(2.475,-6.35) 15(-2.475,-8.89) 16(2.475,-8.89)
  silkscreen extent -1.65,-10.16 1.65,10.3, body extent -3.85,-10.16 3.85,10.16, height 9.65
SNT-100-BK-G [mil] "Samtec STEP model"
  round 1 on Mech3: 0(0,0)
  body extent -100,-50 100,50, height 344
SSOP28_N [mm] "SOP, 28-Leads, Body 10.2x5.3mm, Pitch 0.65mm, IPC Medium Density"
  oval 2.1x0.45 smd: 1(-3.45,4.225) 2(-3.45,3.575) 3(-3.45,2.925) 4(-3.45,2.275) 5(-3.45,1.625) 6(-3.45,0.975) 7(-3.45,0.325) 8(-3.45,-0.325) 9(-3.45,-0.975) 10(-3.45,-1.625) 11(-3.45,-2.275) 12(-3.45,-2.925) 13(-3.45,-3.575) 14(-3.45,-4.225) 15(3.45,-4.225) 16(3.45,-3.575) 17(3.45,-2.925) 18(3.45,-2.275) 19(3.45,-1.625) 20(3.45,-0.975) 21(3.45,-0.325) 22(3.45,0.325) 23(3.45,0.975) 24(3.45,1.625) 25(3.45,2.275) 26(3.45,2.925) 27(3.45,3.575) 28(3.45,4.225)
  silkscreen extent -3.57,-5.3 2,5.3, body extent -2.7,-5.3 2.7,5.3, height 2
Sullins_PBC02SAAN [mm] "Sullins 100mil, 1x2, 230 mil above insulator"
  rect 1.65x1.65 hole 1.016: 1(0,1.27)
  round 1.65 hole 1.016: 2(0,-1.27)
  silkscreen extent -1.37,-2.54 1.27,3.1, body extent -1.27,-2.54 1.27,2.54, height 8.38
SW_FSM4JSMA [mm] "Alcoswitch"
  rrect7% 1.4x2.1 smd: 1(2.25,4.55) 2(2.25,-4.55) 3(-2.25,4.55) 4(-2.25,-4.55)
  body extent -3,-5 3,5, height 5.09
Testpoint_Keystone_Miniature [mil] "Miniature SMT test point"
  rect 135x70 smd: 1(0,0)
  silkscreen extent -78,-46 78,45, body extent -52,-20 52,20, height 61
TI_Stacked_Overlay_Small [mm]
  silkscreen extent -10.63,-2.49 10.63,2.49
TP_H045P075 [mm] "TP_H0.45P0.75"
  round 0.75 hole 0.45: 1(0,0)
WEEE_Minimum [mm] "WEEElie bin"
  silkscreen extent -2.42,-4.38 2.52,2.65
WL-SMCW_GREEN [mm] "WURTH"
  rect 0.8x0.8 smd: 1(-0.8,0) 2(0.8,0)
  silkscreen extent -1.9,-0.8 1.2,0.8, body extent -0.85,-0.45 0.85,0.45, height 0.8
WL-SMCW_RED [mm] "WURTH"
  rect 0.8x0.8 smd: 1(-0.8,0) 2(0.8,0)
  silkscreen extent -1.9,-0.8 1.2,0.8, body extent -0.85,-0.45 0.85,0.45, height 0.8
WL-SMCW_YELLOW [mm] "WURTH"
  rect 0.8x0.8 smd: 1(-0.8,0) 2(0.8,0)
  silkscreen extent -1.9,-0.8 1.2,0.8, body extent -0.85,-0.45 0.85,0.45, height 0.8
Wurth_60900213421 [mil] "Shunt, 2.54mm, Black"
  round 1 on Mech3: 0(0,0)
  body extent -98,-48 98,48, height 338