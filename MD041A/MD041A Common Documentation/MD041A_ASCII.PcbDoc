# Altium PCB MD041A_ASCII.PcbDoc (part 3 of 6)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 6709.84 x 5059.84 mil, 4 copper layers (Top Layer, Signal Layer 1, Signal Layer 2, Bottom Layer), stack 61.2 mil thick; 351 components, 206 nets, 927 pads, 324 vias.

## Design rules (kind name [scope] priority, off if disabled: settings) (continued)
PolygonConnect PolygonConnect_91 [All vs IsNamedPolygon('TOP_LAYER_BOUT2_P242')] p4: thpad.connectstyle=Direct thpad.reliefconductorwidth=10 thpad.reliefentries=4 thpad.polygonreliefangle="90 Angle" thpad.airgapwidth=10 smdpad.connectstyle=Direct smdpad.reliefconductorwidth=10 smdpad.reliefentries=4 smdpad.polygonreliefangle="90 Angle" smdpad.airgapwidth=10 via.connectstyle=Relief via.reliefconductorwidth=10 via.reliefentries=4 via.polygonreliefangle="90 Angle" via.airgapwidth=10
PolygonConnect PolygonConnect_90 [All vs IsNamedPolygon('TOP_LAYER_VM_P239')] p5: thpad.connectstyle=Direct thpad.reliefconductorwidth=10 thpad.reliefentries=4 thpad.polygonreliefangle="90 Angle" thpad.airgapwidth=10 smdpad.connectstyle=Direct smdpad.reliefconductorwidth=10 smdpad.reliefentries=4 smdpad.polygonreliefangle="90 Angle" smdpad.airgapwidth=10 via.connectstyle=Relief via.reliefconductorwidth=10 via.reliefentries=4 via.polygonreliefangle="90 Angle" via.airgapwidth=10
PolygonConnect PolygonConnect_89 [All vs IsNamedPolygon('TOP_LAYER_BOUT1_P240')] p6: thpad.connectstyle=Direct thpad.reliefconductorwidth=10 thpad.reliefentries=4 thpad.polygonreliefangle="90 Angle" thpad.airgapwidth=10 smdpad.connectstyle=Direct smdpad.reliefconductorwidth=10 smdpad.reliefentries=4 smdpad.polygonreliefangle="90 Angle" smdpad.airgapwidth=10 via.connectstyle=Relief via.reliefconductorwidth=10 via.reliefentries=4 via.polygonreliefangle="90 Angle" via.airgapwidth=10
PolygonConnect PolygonConnect_88 [All vs IsNamedPolygon('BOTTOM_LAYER_VM_P080')] p7: thpad.connectstyle=Direct thpad.reliefconductorwidth=10 thpad.reliefentries=4 thpad.polygonreliefangle="90 Angle" thpad.airgapwidth=10 smdpad.connectstyle=Direct smdpad.reliefconductorwidth=10 smdpad.reliefentries=4 smdpad.polygonreliefangle="90 Angle" smdpad.airgapwidth=10 via.connectstyle=Relief via.reliefconductorwidth=10 via.reliefentries=4 via.polygonreliefangle="90 Angle" via.airgapwidth=10
PolygonConnect PolygonConnect_87 [All vs IsNamedPolygon('TOP_LAYER_VM_P125')] p8: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_86 [All vs IsNamedPolygon('BOTTOM_LAYER_VM_P080')] p9: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_85 [All vs IsNamedPolygon('BOTTOM_LAYER_OUT2_P211')] p10: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_84 [All vs IsNamedPolygon('BOTTOM_LAYER_OUT1_P205')] p11: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_83 [All vs IsNamedPolygon('BOTTOM_LAYER_OUT1_P205')] p12: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_82 [All vs IsNamedPolygon('BOTTOM_LAYER_GND_P204')] p13: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_81 [All vs IsNamedPolygon('TOP_LAYER_GND_P237')] p14: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_80 [All vs IsNamedPolygon('TOP_LAYER_GND_P086')] p15: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_79 [All vs IsNamedPolygon('TOP_LAYER_VM_P229')] p16: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_78 [All vs IsNamedPolygon('TOP_LAYER_GND_P086')] p17: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_77 [All vs IsNamedPolygon('TOP_LAYER_OUT1_P221')] p18: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_76 [All vs IsNamedPolygon('TOP_LAYER_OUT2_P173')] p19: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_75 [All vs IsNamedPolygon('TOP_LAYER_OUT2_P173')] p20: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_74 [All vs IsNamedPolygon('TOP_LAYER_OUT2_P173')] p21: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_73 [All vs IsNamedPolygon('TOP_LAYER_OUT1_P221')] p22: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_72 [All vs IsNamedPolygon('TOP_LAYER_GND_P121')] p23: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_71 [All vs IsNamedPolygon('TOP_LAYER_OUT2_P173') Or  IsNamedPolygon('TOP_LAYER_OUT1_P129')] p24: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_70 [All vs IsNamedPolygon('TOP_LAYER_OUT2_P173')] p25: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_69 [All vs IsNamedPolygon('TOP_LAYER_OUT1_P129')] p26: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_68 [All vs IsNamedPolygon('TOP_LAYER_VM_P085')] p27: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_67 [All vs IsNamedPolygon('BOTTOM_LAYER_P_IN_P174')] p28: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_66 [All vs IsNamedPolygon('BOTTOM_LAYER_NETF1_2_P203')] p29: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_65 [All vs IsNamedPolygon('BOTTOM_LAYER_VBAT_P165')] p30: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_64 [All vs IsNamedPolygon('TOP_LAYER_VM_P167')] p31: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_63 [All vs IsNamedPolygon('TOP_LAYER_VM_P167')] p32: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_62 [All vs IsNamedPolygon('TOP_LAYER_VM_P171')] p33: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_61 [All vs IsNamedPolygon('SIGNAL_LAYER_2_GND_P199')] p34: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_60 [All vs IsNamedPolygon('SIGNAL_LAYER_2_NETF1_2_P196')] p35: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_59 [All vs IsNamedPolygon('SIGNAL_LAYER_2_VBAT_P197')] p36: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_58 [All vs IsNamedPolygon('SIGNAL_LAYER_2_P_IN_P198')] p37: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_57 [All vs IsNamedPolygon('SIGNAL_LAYER_2_3V3_P194')] p38: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_56 [All vs IsNamedPolygon('TOP_LAYER_NETF1_2_P207')] p39: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_55 [All vs IsNamedPolygon('TOP_LAYER_VBAT_P223')] p40: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_54 [All vs IsNamedPolygon('TOP_LAYER_P_IN_P227')] p41: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_53 [All vs IsNamedPolygon('TOP_LAYER_GND_P086')] p42: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_52 [All vs IsNamedPolygon('SIGNAL_LAYER_2_VM_P177') Or  IsNamedPolygon('SIGNAL_LAYER_2_VM_P179') Or  IsNamedPolygon('SIGNAL_LAYER_2_VM_P160') Or  IsNamedPolygon('SIGNAL_LAYER_2_VM_P175') Or  IsNamedPolygon('SIGNAL_LAYER_2_VM_P181')] p43: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_51 [All vs IsNamedPolygon('SIGNAL_LAYER_2_EZFET_VBUS_P136')] p44: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_50 [All vs IsNamedPolygon('SIGNAL_LAYER_2_EZFET_VCC_P132')] p45: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_49 [All vs IsNamedPolygon('SIGNAL_LAYER_2_MCU_3V3_P192')] p46: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_48 [All vs IsNamedPolygon('SIGNAL_LAYER_1_GND_P190')] p47: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_47 [All vs IsNamedPolygon('SIGNAL_LAYER_1_GND_P184')] p48: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_46 [All vs IsNamedPolygon('BOTTOM_LAYER_GND_P241')] p49: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_45 [All vs IsNamedPolygon('BOTTOM_LAYER_GND_P241')] p50: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_44 [All vs IsNamedPolygon('BOTTOM_LAYER_OUT2_P163')] p51: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_43 [All vs IsNamedPolygon('BOTTOM_LAYER_VM_P166')] p52: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_42 [All vs IsNamedPolygon('BOTTOM_LAYER_VM_P235')] p53: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_41 [All vs IsNamedPolygon('BOTTOM_LAYER_OUT1_P164')] p54: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_40 [All vs IsNamedPolygon('BOTTOM_LAYER_GND_P162')] p55: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_39 [All vs IsNamedPolygon('SIGNAL_LAYER_2_VM_P160')] p56: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_38 [All vs IsNamedPolygon('SIGNAL_LAYER_2_NONET_P138')] p57: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_37 [All vs IsNamedPolygon('SIGNAL_LAYER_1_VM_P146')] p58: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_36 [All vs IsNamedPolygon('SIGNAL_LAYER_2_GND_P156')] p59: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_35 [All vs IsNamedPolygon('BOTTOM_LAYER_EZFET_USB_SHIELD_P219')] p60: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_34 [All vs IsNamedPolygon('SIGNAL_LAYER_1_VM_P144')] p61: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_33 [All vs IsNamedPolygon('SIGNAL_LAYER_1_VM_P148') Or  IsNamedPolygon('SIGNAL_LAYER_1_VM_P148')] p62: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_32 [All vs IsNamedPolygon('SIGNAL_LAYER_1_GND_P154')] p63: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_31 [All vs IsNamedPolygon('SIGNAL_LAYER_2_NONET_P138')] p64: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_30 [All vs IsNamedPolygon('SIGNAL_LAYER_2_GND_P082')] p65: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_29 [All vs IsNamedPolygon('TOP_LAYER_GND_P076')] p66: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_28 [All vs IsNamedPolygon('TOP_LAYER_GND_P087')] p67: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_27 [All vs IsNamedPolygon('TOP_LAYER_VM_P127') Or  IsNamedPolygon('TOP_LAYER_VM_P085')] p68: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_26 [All vs IsNamedPolygon('TOP_LAYER_GND_P117')] p69: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_25 [All vs IsNamedPolygon('TOP_LAYER_OUT1_P129') Or  IsNamedPolygon('TOP_LAYER_OUT2_P173')] p70: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_24 [All vs IsNamedPolygon('SIGNAL_LAYER_2_NONET_P113')] p71: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_23 [All vs IsNamedPolygon('BOTTOM_LAYER_NONET_P115')] p72: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_22 [All vs IsNamedPolygon('SIGNAL_LAYER_1_NONET_P111')] p73: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_21 [All vs IsNamedPolygon('TOP_LAYER_NONET_P083')] p74: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_20 [All vs IsNamedPolygon('TOP_LAYER_NONET_P105')] p75: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_19 [All vs IsNamedPolygon('TOP_LAYER_OUT2_P107')] p76: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_18 [All vs IsNamedPolygon('TOP_LAYER_NONET_P101')] p77: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_17 [All vs IsNamedPolygon('TOP_LAYER_OUT1_P103')] p78: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_16 [All vs IsNamedPolygon('TOP_LAYER_OUT1_P000')] p79: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_15 [All vs IsNamedPolygon('TOP_LAYER_NONET_P093')] p80: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_14 [All vs IsNamedPolygon('TOP_LAYER_OUT2_P099')] p81: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_13 [All vs IsNamedPolygon('TOP_LAYER_OUT1_P000')] p82: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_12 [All vs IsNamedPolygon('BOTTOM_LAYER_NONET_P079') Or  IsNamedPolygon('SIGNAL_LAYER_2_NONET_P078') Or  IsNamedPolygon('SIGNAL_LAYER_1_NONET_P077') Or  IsNamedPolygon('TOP_LAYER_NONET_P083') Or  IsNamedPolygon('BOTTOM_LAYER_NONET_P072') Or  IsNamedPolygon('SIGNAL_LAYER_2_NONET_P070') Or  IsNamedPolygon('SIGNAL_LAYER_1_NONET_P059') Or  IsNamedPolygon('TOP_LAYER_OUT2_P058') Or  IsNamedPolygon('BOTTOM_LAYER_NONET_P056') Or  IsNamedPolygon('SIGNAL_LAYER_2_NONET_P054') Or  IsNamedPolygon('SIGNAL_LAYER_1_NONET_P052') Or  IsNamedPolygon('TOP_LAYER_OUT1_P050') Or  IsNamedPolygon('BOTTOM_LAYER_VM_P044') Or  IsNamedPolygon('SIGNAL_LAYER_2_VM_P042') Or  IsNamedPolygon('SIGNAL_LAYER_1_VM_P040') Or  IsNamedPolygon('TOP_LAYER_VM_P038') Or  IsNamedPolygon('BOTTOM_LAYER_VM_P036') Or  IsNamedPolygon('SIGNAL_LAYER_2_VM_P018') Or  IsNamedPolygon('SIGNAL_LAYER_1_VM_P016') Or  IsNamedPolygon('TOP_LAYER_VM_P003')] p83: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_11 [All vs IsNamedPolygon('TOP_LAYER_NONET_P089') Or  IsNamedPolygon('TOP_LAYER_NONET_P090')] p84: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_10 [All vs IsNamedPolygon('BOTTOM_LAYER_EZFET_USB_SHIELD_P002') Or  IsNamedPolygon('TOP_LAYER_EZFET_USB_SHIELD_P201') Or  IsNamedPolygon('SIGNAL_LAYER_2_EZFET_VBUS_P018') Or  IsNamedPolygon('SIGNAL_LAYER_2_EZFET_VCC_P016')] p85: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_9 [All vs IsNamedPolygon('TOP_LAYER_VM_P123') Or  IsNamedPolygon('TOP_LAYER_VM_P123') Or  IsNamedPolygon('TOP_LAYER_VM_P123')] p86: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_8 [All vs IsNamedPolygon('TOP_LAYER_NONET_P072')] p87: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_7 [All vs IsNamedPolygon('TOP_LAYER_NONET_P072')] p88: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_6 [All vs IsNamedPolygon('TOP_LAYER_VM_P042')] p89: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_5 [All vs IsNamedPolygon('TOP_LAYER_VM_P044')] p90: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_4 [All vs IsNamedPolygon('TOP_LAYER_VM_P046')] p91: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_3 [All vs IsNamedPolygon('TOP_LAYER_GND_P036') Or  IsNamedPolygon('TOP_LAYER_OUT2_P040') Or  IsNamedPolygon('TOP_LAYER_OUT1_P038')] p92: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_2 [InNet('EZFET_VBUS') vs IsNamedPolygon('TOP_LAYER_EZFET_VBUS_P008')] p93: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect PolygonConnect_1 [InNetClass('Power-Net') vs IsNamedPolygon('TOP_LAYER_EZFET_USB_SHIELD_P201')] p94: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
PolygonConnect [All] p95: connectstyle=Direct reliefconductorwidth=10 reliefentries=4 polygonreliefangle="90 Angle" airgapwidth=10
RoutingCorners [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 cornerstyle=45-Degree minsetback=100 maxsetback=100
RoutingLayers [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 top layer=Automatic mid layer 1=Automatic mid layer 2=Automatic bottom layer=Automatic
RoutingPriority [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0
RoutingTopology [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 topology=Shortest
RoutingVias [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 holewidth=16 width=34 viastyle="Through Hole" minholewidth=7.87 minwidth=26 maxholewidth=40 maxwidth=65
RoutingVias ThermalPadVias [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=63 holewidth=7.87 width=19.68 viastyle="Through Hole" minholewidth=7.87 minwidth=19.68 maxholewidth=12.99 maxwidth=23.62 // Protel DXP Scope 1 Expression Was: IsVia and InAnyComponent
RoutingVias ThermalPadVias [IsVia and InAnyComponent] p1: holewidth=7.87 width=19.68 viastyle="Through Hole" minholewidth=7.87 minwidth=19.68 maxholewidth=12.99 maxwidth=23.62
RoutingVias [All] p2: holewidth=16 width=34 viastyle="Through Hole" minholewidth=7.87 minwidth=26 maxholewidth=40 maxwidth=65
ShortCircuit [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 allowed=FALSE
SilkToBoardRegionClearance [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=130 // Protel DXP Scope 1 Expression Was: Not ((IsComment or IsDesignator) And (Hide <> 'False')) and not InRegion(1000,500,4000,800)
SilkToBoardRegionClearance [Not ((IsComment or IsDesignator) And (Hide <> 'False')) and not InRegion(1000,500,4000,800)] p1:
SilkToSilkClearance [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0
SilkToSilkClearance SilkToSilkClearance_Pb-FreeLogo [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=120 // Protel DXP Scope 2 Expression Was: (HasFootprint('Pb-Free_Overlay_Medium') OR HasFootprint('Pb-Free_Overlay_Small'))
SilkToSilkClearance SilkToSilkClearance_Pb-FreeLogo [(HasFootprint('Pb-Free_Overlay_Medium') OR HasFootprint('Pb-Free_Overlay_Small')) vs (HasFootprint('Pb-Free_Overlay_Medium') OR HasFootprint('Pb-Free_Overlay_Small'))] p1: silktosilkclearance=0
SilkToSilkClearance [All] p2: silktosilkclearance=3.94
SilkToSolderMaskClearance "Silk to Solder Mask Opening" [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0
SilkToSolderMaskClearance SilkToComponentPadClearance [All] p0 off: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=87 // Protel DXP Scope 1 Expression Was: (IsPad or IsFill or IsRegion) and InAnycomponent
SilkToSolderMaskClearance SilkToComponentPadClearance [(IsPad or IsFill or IsRegion) and InAnycomponent] p1: minsilkscreentomaskgap=5 clearancetoexposedcopper=TRUE
SilkToSolderMaskClearance "Silk to Solder Mask Opening" [All] p2: minsilkscreentomaskgap=3.94 clearancetoexposedcopper=FALSE
SolderMaskExpansion [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 expansion=1.97
SolderMaskExpansion [All] p1: expansion=1.97 istentingtop=FALSE
UnRoutedNet [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0
UnRoutedNet [All] p1: checkbadconnections=TRUE
UnpouredPolygon [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0
Width [All] p0: scope1count=1 scope1_0_kind=Board scope1_0_value=Board scope2count=1 scope2_0_kind=Board scope2_0_value=Board commentlength=0 maxlimit=160 minlimit=6 preferedwidth=10
Width [All] p1: maxlimit=160 minlimit=6 preferedwidth=10 checkconnectedcopper=TRUE
14 further rules are at their usual default settings.

## Classes and differential pairs
net class Power-Net: EZFET_VBUS EZFET_VCC GND MCU_3V3
component class Shunt: SH-J1 SH-J2 SH-J3 SH-J4 SH-J5 SH-J6 SH-J7 SH-J8 SH-J9 SH-J10 SH-J11 SH-J12 SH-J13 SH-J14 SH-J15 SH-J16 SH-J17 SH-J18 SH-J19 SH-J20 SH-J21 SH-J22 SH-J23 SH-J24 SH-J25 SH-J26 SH-J27 SH-J28 SH-J29 SH-J30 SH-J31 SH-J32 SH-J33 SH-J34 SH-J35
component class MD041_Motor_Driver_RevA: C49 C50 C51 C52 C53 C54 C55 C56 C57 C58 C59 C60 C61 C63 C64 C65 C66 C67 C68 C69 C70 C71 C75 D4 D5 D6 D7 D8 D9 D10 D11 D12 D13 DVDD F1 F2 J3 J12 J13 J14 J15 J16 J17 J18 J19 J20 J21 J22 J23 J24 J27 MP1 Q1 R79 R80 R81 R82 R83 R84 R85 R86 R87 R88 R89 R90 R91 R92 R93 R94 R95 R96 R97 R98 R99 R100 R101 R102 R103 R104 R105 R106 R107 R108 R109 R110 R111 R112 R113 R114 R115 R116 R117 R118 S1 SH-J18 SH-J19 SH-J20 SH-J21 SH-J22 SH-J32 SH-J33 SH-J34 SH-J35 TP28 TP29 TP30 TP31 TP32 TP34 TP35 TP36 U7
component class MD041_Motor_control_RevA: A1 A2 A3 A4 C1 C2 C3 C4 C5 C6 C7 C8 C9 C10 C11 C12 C13 C14 C15 C16 C17 C18 C19 C62 C72 C73 C74 J1 J2 J4 J5 J6 J7 J8 J25 J26 R1 R2 R3 R4 R5 R6 R7 R8 R9 R10 R11 R12 R13 R14 R15 R16 R17 R18 R19 R21 R23 R24 R25 R26 R27 R29 R30 R32 R33 R34 R35 R39 R40 R41 R42 R44 R49 R54 SH-J1 SH-J2 SH-J3 SH-J4 SH-J5 SH-J6 SH-J7 SH-J8 SH-J9 SH-J10 SH-J11 SH-J12 SH-J13 SH-J14 SH-J15 SH-J16 SH-J17 SH-J30 SH-J31 TP1 TP2 TP3 TP4 TP5 TP6 TP7 TP8 TP9 TP10 TP11 TP12 TP13 TP14 TP15 TP16 TP17 TP18 TP19 TP20 TP21 TP22 TP23 TP24 TP25 TP26 TP27 TP37 TP38 TP39 TP40 TP41 TP42 TP43 TP44 TP45 TP46 U1 Y2
component class MD041_ezFET_RevA: C20 C21 C22 C23 C24 C25 C26 C27 C28 C29 C30 C31 C32 C33 C34 C35 C36 C37 C38 C39 C40 C41 C42 C43 C44 C45 C46 C47 C48 D1 D2 D3 J9 J10 J11 L1 L2 R55 R56 R57 R58 R59 R60 R61 R62 R63 R64 R65 R66 R67 R68 R69 R70 R71 R72 R73 R74 R75 R76 R77 R78 SH-J23 SH-J24 SH-J25 SH-J26 SH-J27 SH-J28 SH-J29 U2 U3 U4 U5 U6 Y1
component class Header: J4 J5 J6 J7 J8 J9 J10 J16 J17 J18 J19 J20 J25 J26 J27
component class Label: LBL1
component class AssemblyNote: ZZ1 ZZ2 ZZ3 ZZ4
component class FiducialMark: FID1 FID2 FID3 FID4
component class MD041_Hardware_RevA: FID1 FID2 FID3 FID4 H1 H1_Nut H2 H2_Nut H3 H3_Nut H4 H4_Nut H5 H5_Nut H6 H6_Nut LBL1 LOGO1 Logo2 Logo3 Logo4 Logo5 Logo6 LOGO7 ZZ1 ZZ2 ZZ3 ZZ4
component class Logo: Logo3
differential pair USB_D: +USB_D_P -USB_D_N
differential pair " ": +EZFET_D_P -EZFET_D_N

## Components (designator, comment, footprint, x,y, rotation, side; value= is the part's Value field where it differs from the comment)
A1 "5012" Keystone5012 1736.04,2709.36 r0 top
A2 "5012" Keystone5012 1546.8,2709.36 r0 top
A3 "5012" Keystone5012 1357.57,2709.36 r0 top
A4 "5012" Keystone5012 1168.33,2709.36 r0 top
C1 "C1005C0G1H330J050BA" 0402 2668.3,334 r270 top
C2 "C1005C0G1H330J050BA" 0402 2755.35,337 r270 top
C3 "C1005C0G1H330J050BA" 0402 2728.82,640.26 r90 top
C4 "C1005C0G1H330J050BA" 0402 2728.82,760.77 r90 top
C5 "C1005C0G1H330J050BA" 0402 2728.82,878.88 r90 top
C6 "C1005C0G1H330J050BA" 0402 2728.82,996.99 r90 top
C7 "885012105010" 0402 750,2900 r0 top
C8 "885012105010" 0402 1380,2075 r180 top
C9 "885012105010" 0402 1380,2015 r180 top
C10 "885012105010" 0402 1380,1950 r180 top
C11 "885012105010" 0402 1425,1890 r180 top
C12 "885012105010" 0402 1780,3435 r270 top
C13 "885012106008" FP-885012106008_0603-MFG 485,2085 r270 top
C14 "T520A106M010ATE080" 3216-18 989.72,1125 r180 top
C15 "885012105010" 0402 1030,2320 r180 top
C16 "885012105010" 0402 485,2205 r270 top
C17 "885012105010" 0402 904,1227.45 r180 top
C18 "885012105010" 0402 1370,1781.38 r90 top
C19 "885012005058" FP-885012005058_0402-MFG 2558.39,2647.52 r180 top
C20 "C1005X5R1A475M050BC" 0402 1241.75,4181.75 r45 top
C21 "885012105010" 0402 1395.65,3900.7 r315 top
C22 "885012005058" FP-885012005058_0402-MFG 764.92,4390.81 r180 top
C23 "885012205061" 0402 532.35,4544.78 r270 top
C24 "885012005058" FP-885012005058_0402-MFG 763.21,4547.39 r180 top
C25 "885012105010" 0402 842.35,4278.16 r90 top
C26 "885012005055" 0402 1339.03,3587 r180 top
C27 "885012005055" 0402 1494.97,3331 r180 top
C28 "885012105011" 0402 1179.2,4244.19 r45 top
C29 "885012106008" FP-885012106008_0603-MFG 572.75,4173.4 r90 top
C30 "885012105011" 0402 1210.66,4212.69 r45 top
C31 "T520A106M010ATE080" 3216-18 661.3,4199.84 r90 top
C32 "885012105010" 0402 792.96,4266.26 r90 top
C33 "885012105010" 0402 742.85,4254.44 r90 top
C34 "885012105010" 0402 1121.97,3753.76 r225 top
C35 "885012105012" 0402 1240.16,4525.59 r90 top
C36 "GRM155R61A104KA01D" 0402 1295.28,4525.59 r90 top
C37 "GRM155R71C103KA01D" 0402 1348.43,4524.61 r90 top
C38 "GRM155R61C225KE11D" 0402 1291.34,4416.34 r90 top
C39 "GRM155R71C103KA01D" 0402 1370.75,4214.62 r0 top
C40 "885012105012" 0402 1240.16,4417.32 r90 top
C41 "885012105010" 0402 2224.35,4331 r90 top
C42 "885012005055" 0402 1475.25,4257.66 r180 top
C43 "885012005055" 0402 1578.04,4257.66 r0 top
C44 "HMK107BJ104MA-T" FP-0603-L_1_6_0_1-W_0_8_0-IPC_B 2086.99,3962.5 r270 top
C45 "885012105012" 0402 1587.35,3961.01 r270 top
C46 "GRM21BC81E335KA73L" 0805_HV 1975.83,3903.94 r270 top
C47 "885012105011" 0402 1810.35,4798.03 r0 top
C48 "885012105010" 0402 1418.26,4513.31 r270 top
C49 "C2012X7R1H105K125AB" 0805_HV 3529.53,2587.6 r270 top
C50 "885012206120" FP-885012206120_0603-MFG 4240,2570 r180 top
C51 "C2012X7R1H105K125AB" 0805_HV 4895.67,2402.56 r0 top
C52 "885012006085" FP-885012006085_0603-MFG 6362.91,3247.91 r270 top
C53 "EMVY101ARA101MKE0S" FP-EMVY101ARA101MKE0S_RADIAL-MFG 5295.28,4047.24 r180 top
C54 "885012006085" FP-885012006085_0603-MFG 3090.5,4322.46 r180 bottom
C55 "885012206120" FP-885012206120_0603-MFG 3087.84,4244.07 r180 bottom
C56 "CGA6M2X7R2A105K200AA" 1210_220 5035.6,2478.25 r90 top
C57 "885012206114" 0603L 4952.62,2044.85 r0 top
C58 "885012206114" 0603L 5146.81,2444.58 r90 top
C59 "885012206114" 0603L 5005,1750 r0 top
C60 "885012006085" FP-885012006085_0603-MFG 6404.15,2813.91 r270 bottom
C61 "885012006085" FP-885012006085_0603-MFG 6355.91,2430.84 r0 top
C62 "885012105010" 0402 3415,2645 r0 top
C63 "885012206120" FP-885012206120_0603-MFG 3410,2560 r270 top
C64 "885012006085" FP-885012006085_0603-MFG 6152.56,1343.5 r45 top
C65 "885012006085" FP-885012006085_0603-MFG 6401.91,1778.91 r90 bottom
C66 "885012006085" FP-885012006085_0603-MFG 6356.91,2325.91 r0 top
C67 "885012005080" FP-885012005080_0402-MFG 6443.91,3538.35 r90 top
C68 "885012005080" FP-885012005080_0402-MFG 6447.5,3840.35 r90 top
C69 "885012005080" FP-885012005080_0402-MFG 6440.8,4124.73 r90 top
C70 "885012005080" FP-885012005080_0402-MFG 6449.75,4420.22 r90 top
C71 "885012005080" FP-885012005080_0402-MFG 5050,265 r270 top
C72 "885012205031" 0402 980,2640 r90 top
C73 "885012205031" 0402 1045,2640 r90 top
C74 "885012006085" FP-885012006085_0603-MFG 1725,2390 r270 top
C75 "EMVY101ARA101MKE0S" FP-EMVY101ARA101MKE0S_RADIAL-MFG 5685.04,879.92 r90 top
D1 "150060RS75000" WL-SMCW_RED 575.97,4353.09 r270 top
D2 "150060VS75000" WL-SMCW_GREEN 482.35,4353.1 r270 top
D3 "MMDL770T1G" ONSC-SOD-323-2-477-02_V 1393.18,4659 r180 top
D4 "150060VS75000" WL-SMCW_GREEN 3085.9,4472.39 r0 top
D5 "150060VS75000" WL-SMCW_GREEN 1681.35,3502 r90 top
D6 "150060VS75000" WL-SMCW_GREEN 328.3,2285.58 r0 top
D7 "150060SS75000" WL-SMCW_RED 3166.5,1790 r0 top
D8 "150060VS75000" WL-SMCW_GREEN 328.34,2165.73 r0 top
D9 "150060YS75000" WL-SMCW_YELLOW 328.75,2040.05 r0 top
D10 "150060YS75000" WL-SMCW_YELLOW 328.7,1914.77 r0 top
D10 "150060YS75000" WL-SMCW_YELLOW 328.7,1914.77 r0 top
D10 "150060VS75000" WL-SMCW_GREEN 328.7,1914.51 r0 top
D11 "150060YS75000" WL-SMCW_YELLOW 328.7,1795.61 r0 top
D11 "150060YS75000" WL-SMCW_YELLOW 328.7,1795.61 r0 top
D11 "150060VS75000" WL-SMCW_GREEN 328.7,1795.61 r0 top
D12 "150060YS75000" WL-SMCW_YELLOW 327.47,1661.54 r0 top
D12 "150060YS75000" WL-SMCW_YELLOW 327.47,1661.54 r0 top
D12 "150060SS75000" WL-SMCW_RED 327.8,1661.57 r0 top
D13 "BZX84J-B4V7,115" FP-BZX84J-B4V7,115_SC90-MFG 2741.41,4547.68 r180 top
F1 "0463015.ER" Fuse_0463 4035,4017 r0 top
F2 "0463015.ER" Fuse_0463 4035,3825 r0 top
FID1 "Fiducial" Fiducial10-20 103.09,4946.26 r0 top
FID2 "Fiducial" Fiducial10-20 85,80 r90 top
FID3 "Fiducial" Fiducial10-20 6620,95 r0 top locked
FID4 "Fiducial" Fiducial10-20 6615,4970 r90 top
H1 "4822" KEYSTONE_4822#1 6415,4785 r180 bottom
H1_Nut "9605" Keystone_9605 6415,4785 r0 top
H2 "4822" KEYSTONE_4822#2 6410,250 r0 bottom locked
H2_Nut "9605" Keystone_9605 6410,250 r0 top locked
H3 "4822" KEYSTONE_4822#1 285,4780 r180 bottom
H3_Nut "9605" Keystone_9605 285,4780 r0 top
H4 "4822" KEYSTONE_4822#1 305,260 r180 bottom
H4_Nut "9605" Keystone_9605 305,260 r0 top
H5 "4822" KEYSTONE_4822#1 4580,320 r180 bottom
H5_Nut "9605" Keystone_9605 4580,320 r0 top
H6 "4822" KEYSTONE_4822#1 4630,3835 r180 bottom
H6_Nut "9605" Keystone_9605 4630,3835 r0 top
J1 "SSQ-110-03-G-D" Samtec_SSQ-110-03-x-D 2941.3,593.45 r90 bottom
J2 "SSQ-110-03-G-D" Samtec_SSQ-110-03-x-D 1242.32,594.09 r90 bottom
J3 "D3082-05" Harwin_D3082-05 5685,188.98 r180 top
J4 "TSM-108-01-L-DV" Samtec_TSM-108-01-x-DV 2492.56,2145 r0 top
J5 "PBC02SAAN" Sullins_PBC02SAAN 3400,2810 r0 top
J6 "PBC02SAAN" Sullins_PBC02SAAN 2805,2855 r270 top
J7 "PBC02SAAN" Sullins_PBC02SAAN 2815,2705 r270 top
J8 "TSM-108-01-L-DV" Samtec_TSM-108-01-x-DV 2502.56,3310 r0 top
J9 "61301421121" Wurth_61301421121 870.78,4842.4 r270 top
J10 "61301421121" Wurth_61301421121 996.35,3410.02 r270 top
J11 "1051640001" Molex_1051640001 1510.21,4963.27 r180 top
J12 "691256610002" FP-691256610002_HDR2-MFG 4121.35,4662 r180 top
J13 "691250610002" FP-691250610002_CONN_TERM_BLOCK2-MFG 6455,1781.09 r90 top
J14 "691250610002" FP-691250610002_CONN_TERM_BLOCK2-MFG 6455,2805.14 r90 top
J15 "D3082-05" Harwin_D3082-05 2790,4705 r180 top
J16 "PBC02SAAN" Sullins_PBC02SAAN 3452.26,2333.72 r90 top
J17 "PBC02SAAN" Sullins_PBC02SAAN 3452.26,1709.61 r90 top
J18 "PBC02SAAN" Sullins_PBC02SAAN 3452.41,1912.98 r90 top
J19 "PBC02SAAN" Sullins_PBC02SAAN 3655.21,2027.86 r0 top
J20 "PBC02SAAN" Sullins_PBC02SAAN 3452.26,2149.15 r90 top
J21 "D3082-05" Harwin_D3082-05 163.35,3732 r90 top
J22 "D3082-05" Harwin_D3082-05 5722.44,2058.07 r90 top
J23 "691250610002" FP-691250610002_CONN_TERM_BLOCK2-MFG 6455,994.08 r90 top
J24 "D3082-05" Harwin_D3082-05 6149.61,2198.82 r90 top
J25 "PBC02SAAN" Sullins_PBC02SAAN 3045,2860 r270 top
J26 "PBC02SAAN" Sullins_PBC02SAAN 3240,2810 r0 top
J27 "61300311121" WURTH_61300311121 1825,2520 r0 top
L1 "BLM18AG151BH1D" 0603 1280.45,4708.31 r270 top
L2 "BLM18AG151BH1D" 0603 1583.57,4652.72 r270 top
LBL1 "THT-14-423-10" Label_650x200 2695,4015 r0 top
LOGO1 "CAUTION HOT SURFACE" IEC_HotSurface_Small 5729.33,2748.03 r0 top
Logo2 "CE Mark" CE_Mark_5mm 2041.35,880.84 r180 bottom
Logo3 "Texas Instruments" TI_Stacked_Overlay_Small 1985,950 r0 top
Logo4 "FCC disclaimer" FCC_disclaimer 8741.35,-1522.39 r90 bottom
Logo5 "WEEE logo" WEEE_Minimum 2060.35,553.08 r180 bottom
Logo6 "CAUTION.  READ USER GUIDE BEFORE USE" IEC_Caution_Small 2142.72,524.61 r0 top
LOGO7 "CAUTION HOT SURFACE" IEC_HotSurface_Small 4588.58,2147.64 r180 bottom
MP1 "ATS-TI10P-519-C1-R3" FP-ATS-TI10P-519-C1-R3_HEAT_SINK-MFG 4587.35,2041 r90 top
Q1 "BC846BLT1G" ONSC-SOT-23-3-318-08_V 2928.42,4497.5 r0 top
R1 "Resistor" 0402L 3120.43,140.69 r180 top
R2 "CRCW0603330KJNEA" 0603L 670,2255 r180 top
R3 "CRCW0603330KJNEA" 0603L 525,1410 r90 top
R4 "CH0402-10RJFPT" FP-CH0402-10RJFPT_0402-MFG 865,2905 r90 top
R5 "Resistor" 0402L 6320.28,3542.91 r90 top
R6 "Resistor" 0402L 3118.46,846.4 r180 top
R7 "Resistor" 0402L 6379.5,3543.35 r90 top
R8 "Resistor" 0402L 6322.91,3846.22 r90 top
R9 "Resistor" 0402L 1455.07,138.72 r180 top
R10 "Resistor" 0402L 6380.5,3841.67 r90 top
R11 "Resistor" 0402L 1455.08,743.45 r180 top
R12 "Resistor" 0402L 6377.5,4125.35 r90 top
R13 "Resistor" 0402L 6328.91,4125.35 r90 top
R14 "Resistor" 0402L 2605,950 r0 top
R15 "Resistor" 0402L 6384.15,4430.22 r90 top
R16 "Resistor" 0402L 6337.15,4434.04 r90 top
R17 "Resistor" 0402L 2605,850 r0 top
R18 "Resistor" 0402L 2607.6,731.24 r0 top
R19 "CRCW060310K0FKEA" 0603 2731.51,1127 r180 top
R21 "Resistor" 0402L 2606.65,615.26 r0 top
R23 "Resistor" 0402L 1450.35,950 r180 top
R24 "Resistor" 0402L 1456.04,243.45 r180 top
R25 "Resistor" 0402L 1449.35,841 r180 top
R26 "Resistor" 0402L 1450.04,638.3 r180 top
R27 "Resistor" 0402L 3118.46,739.12 r180 top
R29 "CRCW040247K0JNED" 0402 1609.25,1897.64 r90 top
R30 "Resistor" 0402L 1450,1090 r180 top
R32 "Resistor" 0402L 1455.07,341.48 r180 top
R33 "Resistor" 0402L 3118.46,544.24 r180 top
R34 "Resistor" 0402L 1455.07,445.81 r180 top
R35 "CH0402-10RJFPT" FP-CH0402-10RJFPT_0402-MFG 865,2730 r270 top
R39 "CRCW04021K00FKED" 0402L 2245,2395 r0 top
R40 "CRCW04021K00FKED" 0402L 2245,2295 r0 top
R41 "CRCW04021K00FKED" 0402L 2245,2195 r0 top
R42 "CRCW04021K00FKED" 0402L 2245,2095 r0 top
R44 "CRCW060310K0FKEA" 0603 2558.39,2812.52 r180 top
R49 "CRCW060310K0FKEA" 0603 2559.88,2732.52 r0 top
R54 "Resistor" 0402L 1840,2265 r90 top
R55 "RC0402FR-07220KL" 0402 762.74,4491.87 r180 top
R56 "CRCW0402240KFKED" 0402 762.74,4646.78 r180 top
R57 "CRCW040247K0JNED" 0402 593.25,4544.78 r270 top
R58 "CRCW0402470RJNED" 0402 504.92,4173.23 r270 top
R59 "CRCW0402560RJNED" 0402 455.71,4173.23 r270 top
R60 "RC0402FR-07220KL" 0402 762.74,4442.46 r0 top
R61 "CRCW0402150KFKED" 0402 762.46,4599.22 r0 top
R62 "ERJ-2GE0R00X" 0402L 1105.5,4599.22 r90 top
R63 "ERJ-2GE0R00X" 0402L 1146.88,4599.22 r90 top
R64 "CRCW040210R0FKED" 0402 1220.48,3612.09 r225 top
R65 "CRCW040210R0FKED" 0402 1121.13,3612.09 r225 top
R66 "CRCW040210R0FKED" 0402 1022.05,3612.15 r225 top
R67 "CRCW040210R0FKED" 0402 921.77,3612.09 r225 top
R68 "Resistor" 0402L 1506.85,4086.04 r270 top
R69 "Resistor" 0603L 1720.15,4594 r0 top
R70 "Resistor" 0603L 1721.42,4488.9 r180 top
R71 "CRCW040227R0JNED" 0402 1717.73,4188.18 r0 top
R72 "CRCW040227R0JNED" 0402 1505.29,4451.57 r270 top
R73 "CRCW040227R0JNED" 0402 1718.35,4251.15 r0 top
R74 "0" RESC1005X40X25NL05T05 1488.35,4019.83 r180 top
R75 "CRCW040227R0JNED" 0402 1553.72,4451.57 r270 top
R76 "CRCW04021K40FKED" 0402 1302.24,4067.33 r315 top
R77 "CRCW04021M00JNED" 0402 1330.7,4097.35 r135 top
R78 "CRCW040233K0JNED" 0402 1810.35,4861 r180 top
R79 "ERJ-2RKF3301X" 0402L 3278.35,2470 r0 top
R80 "ERJ-2RKF3301X" 0402L 3035,2045 r180 top
R81 "ERJ-2RKF3301X" 0402L 3333.66,2024.61 r0 top
R82 "ERJ-2RKF3301X" 0402L 3197.83,2125 r0 top
R83 "RC0603JR-0710KL" 0603L 3035,1710 r0 top
R84 "CRCW04020000Z0EDHP" 0402 3175,2475 r0 top
R85 "CRCW04020000Z0EDHP" 0402 3133.62,2045 r180 top
R86 "CRCW04020000Z0EDHP" 0402 3242.13,2045.28 r0 top
R87 "CRCW04020000Z0EDHP" 0402 3101.38,2128.94 r0 top
R88 "RC0603JR-0710KL" 0603L 3050,1895 r0 top
R89 "CRCW060386K6FKEA" 0603L 6527.91,3421.51 r270 top
R90 "CRCW060386K6FKEA" 0603L 6519.12,3707.41 r270 top
R91 "CRCW060386K6FKEA" 0603L 6529.39,3996.78 r270 top
R92 "CRCW060386K6FKEA" 0603L 6529.95,4306.91 r270 top
R93 "CRCW06034K99FKEA" 0603L 6527.91,3534.91 r270 top
R94 "CRCW06034K99FKEA" 0603L 6520.05,3851.11 r270 top
R95 "CRCW06034K99FKEA" 0603L 6529.39,4124.73 r270 top
R96 "CRCW06034K99FKEA" 0603L 6528.91,4428.91 r270 top
R97 "CRCW040247K0JNED" 0402 3078.62,4540 r0 top
R98 "CRCW060397K6FKEA" 0603 5153.35,386.58 r90 top
R99 "RC0603JR-0710KL" 0603L 238.15,2635.98 r90 top
R100 "RC0603JR-0710KL" 0603L 379.24,2634.65 r90 top
R101 "RC0603JR-0710KL" 0603L 500,2632.44 r90 top
R102 "RC0603JR-0710KL" 0603L 1525.6,1444.2 r180 top
R103 "RC0603JR-0710KL" 0603L 1525.56,1533.65 r180 top
R104 "CRCW06034K99FKEA" 0603L 5153.59,273.18 r90 top
R105 "RC0603JR-0710KL" 0603L 238.15,2748.43 r90 top
R106 "RC0603JR-0710KL" 0603L 378.07,2749.65 r90 top
R107 "RC0603JR-0710KL" 0603L 499,2747.65 r90 top
R108 "RC0603JR-0710KL" 0603L 1412.2,1444.2 r180 top
R109 "RC0603JR-0710KL" 0603L 1412.16,1533.65 r180 top
R110 "RC0603FR-07560RL" 0603 1680.12,3361.22 r90 top
R111 "Resistor" 0603L 197.82,1914.51 r0 top
R112 "Resistor" 0603L 3032.44,1790 r0 top
R113 "Resistor" 0603L 194,2165.73 r0 top
R114 "Resistor" 0603L 192,2286.09 r0 top
R115 "Resistor" 0603L 193.31,2039.95 r0 top
R116 "Resistor" 0603L 197.57,1794.46 r0 top
R117 "Resistor" 0603L 198.19,1661.73 r0 top
R118 "RC0603FR-07470RL" 0603 2730.47,4458.61 r0 top
S1 "430481025816" FP-430481025816_SMT_SW_6MM2_6MM2-MFG 2115,2760 r0 top
SH-J1 "60900213421" Wurth_60900213421 2502.95,3662.4 r0 top
SH-J2 "60900213421" Wurth_60900213421 2502.95,3561.87 r0 top
SH-J3 "60900213421" Wurth_60900213421 2502.95,3461.33 r0 top
SH-J4 "60900213421" Wurth_60900213421 2502.95,3360.8 r0 top
SH-J5 "60900213421" Wurth_60900213421 2502.95,3260.26 r0 top
SH-J6 "60900213421" Wurth_60900213421 2502.95,3159.73 r0 top
SH-J7 "60900213421" Wurth_60900213421 2502.95,3059.2 r0 top
SH-J8 "60900213421" Wurth_60900213421 2502.95,2958.66 r0 top
SH-J9 "60900213421" Wurth_60900213421 2489.17,2503.94 r0 top
SH-J10 "60900213421" Wurth_60900213421 2489.17,2402.84 r0 top
SH-J11 "60900213421" Wurth_60900213421 2489.17,2301.74 r0 top
SH-J12 "60900213421" Wurth_60900213421 2489.17,2200.65 r0 top
SH-J13 "60900213421" Wurth_60900213421 2489.17,2099.55 r0 top
SH-J14 "60900213421" Wurth_60900213421 2489.17,1998.45 r0 top
SH-J15 "60900213421" Wurth_60900213421 6835,2219.16 r90 top
SH-J16 "60900213421" Wurth_60900213421 2489.17,1897.36 r0 top
SH-J17 "60900213421" Wurth_60900213421 2489.17,1796.26 r0 top
SH-J18 "60900213421" Wurth_60900213421 2801.18,2854.33 r0 top
SH-J19 "60900213421" Wurth_60900213421 3241.14,2810.04 r90 top
SH-J20 "60900213421" Wurth_60900213421 6835,1957.02 r90 top
SH-J21 "60900213421" Wurth_60900213421 6835,1694.88 r90 top
SH-J22 "60900213421" Wurth_60900213421 1775.59,2524.61 r0 top
SH-J23 "60900213421" Wurth_60900213421 6830.71,2481.3 r90 top
SH-J24 "60900213421" Wurth_60900213421 892.72,3410.43 r90 top
SH-J25 "60900213421" Wurth_60900213421 993.11,3410.43 r90 top
SH-J26 "60900213421" Wurth_60900213421 1093.5,3410.43 r90 top
SH-J27 "60900213421" Wurth_60900213421 1093.5,3410.43 r90 top
SH-J28 "60900213421" Wurth_60900213421 1193.9,3410.43 r90 top
SH-J29 "60900213421" Wurth_60900213421 1294.29,3410.43 r90 top
SH-J30 "60900213421" Wurth_60900213421 6835,1432.74 r90 top
SH-J31 "60900213421" Wurth_60900213421 6835,1170.6 r90 top
SH-J32 "60900213421" Wurth_60900213421 6835,908.46 r90 top
SH-J33 "60900213421" Wurth_60900213421 6835,646.33 r90 top
SH-J34 "60900213421" Wurth_60900213421 6835,384.19 r90 top
SH-J35 "60900213421" Wurth_60900213421 6835,122.05 r90 top
TP1 "TP_H0.45P0.75" TP_H045P075 910,2295 r0 top
TP2 "TP_H0.45P0.75" TP_H045P075 875,2195 r0 top
TP3 "TP_H0.45P0.75" TP_H045P075 840,2295 r0 top
TP4 "TP_H0.45P0.75" TP_H045P075 810,2195 r0 top
TP5 "TP_H0.45P0.75" TP_H045P075 765,2295 r0 top
TP6 "TP_H0.45P0.75" TP_H045P075 535,1710 r0 top
TP7 "TP_H0.45P0.75" TP_H045P075 470,1680 r0 top
TP8 "TP_H0.45P0.75" TP_H045P075 535,1645 r0 top
TP9 "TP_H0.45P0.75" TP_H045P075 470,1610 r0 top
TP10 "TP_H0.45P0.75" TP_H045P075 765,1355 r0 top
TP11 "TP_H0.45P0.75" TP_H045P075 835,1320 r0 top
TP12 "TP_H0.45P0.75" TP_H045P075 830,1385 r0 top
TP13 "5012" Keystone5012 1547.24,2134.84 r0 top
TP14 "5012" Keystone5012 717.91,2709.36 r0 top
TP15 "5012" Keystone5012 1546.8,2327.76 r0 top
TP16 "5012" Keystone5012 1546.8,1681.57 r0 top
TP17 "5012" Keystone5012 1546.8,2508.86 r0 top
TP18 "TP_H0.45P0.75" TP_H045P075 1166.29,1236.53 r0 top
TP19 "TP_H0.45P0.75" TP_H045P075 1186.24,1300 r0 top
TP20 "TP_H0.45P0.75" TP_H045P075 1229.76,1236 r0 top
TP21 "TP_H0.45P0.75" TP_H045P075 1249.71,1300 r0 top
TP22 "TP_H0.45P0.75" TP_H045P075 1293.24,1234 r0 top
TP23 "TP_H0.45P0.75" TP_H045P075 1325,1300 r0 top