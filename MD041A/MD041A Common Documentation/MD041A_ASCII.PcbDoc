# Altium PCB MD041A_ASCII.PcbDoc (part 5 of 6)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 6709.84 x 5059.84 mil, 4 copper layers (Top Layer, Signal Layer 1, Signal Layer 2, Bottom Layer), stack 61.2 mil thick; 351 components, 206 nets, 927 pads, 324 vias.

## Via types
v1: diameter 19.68, hole 13.78, Top Layer to Bottom Layer, tented both sides, 174 vias
v2: diameter 34, hole 16, Top Layer to Bottom Layer, tented both sides, 114 vias
v3: diameter 19.68, hole 7.87, Top Layer to Bottom Layer, 22 vias
v4: diameter 23.62, hole 11.81, Top Layer to Bottom Layer, tented both sides, 6 vias
v5: diameter 141.73, hole 141.73, Top Layer to Bottom Layer, tented both sides, 6 vias
v6: diameter 201.73, hole 141.73, Top Layer to Bottom Layer, 2 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
GND: C1.2 C2.2 C3.2 C4.2 C5.2 C6.2 C7.1 C8.1 C9.1 C10.1 C11.1 C12.2 C13.2 C14.2 C15.2 C16.2 C17.2 C18.2 C19.2 C20.2 C21.2 C22.2 C23.2 C24.2 C25.2 C26.1 C27.1 C28.2 C29.2 C30.2 C31.2 C32.2 C33.2 C34.2 C35.2 C36.2 C37.2 C38.2 C39.2 C40.2 C41.2 C42.2 C43.2 C44.2 C45.2 C46.2 C47.2 C48.2 C49.1 C52.1 C53.1 C54.2 C55.2 C56.2 C57.2 C58.2 C59.2 C61.1 C62.1 C63.1 C64.1 C66.1 C67.2 C68.2 C69.2 C70.2 C71.2 C74.2 C75.1 D1.1 D2.1 D13.2 J1.4 J2.2 J3.1 J3.2 J9.9 J10.13 J10.14 J12.1 J15.1 J15.2 J21.1 J21.2 J23.2 L2.2 MP1. R49.1 R60.1 R61.1 R77.1 R78.1 R84.1 R85.1 R86.1 R87.1 R93.1 R94.1 R95.1 R96.1 R104.1 R105.2 R106.2 R107.2 R108.2 R109.2 R110.1 R111.1 R113.1 R114.1 R115.1 R116.1 R117.1 R118.1 S1.3 S1.4 TP25.1 TP29.1 U1.10 U1.12 U1.15 U1.26 U1.29 U1.63 U1.76 U1.83 U1.90 U2.14 U2.16 U2.39 U2.49 U2.56 U2.65 U3.4 U3.9 U4.7 U4.18 U4.21 U4.25 U4.26 U5.2 U5.4 U5.5 U5.7 U5.11 U6.4 U7.1 U7.3 U7.10 U7.13 U7.20 U7.44 Y1.2 Y2.3 | length 14028.8
  Top Layer w6: v1@1128.68,4358.76 v1(1132.62,4358.76) ; C48.2@1418.26,4489.69 1457.79,4489.69 v1(1458.3,4489.18)
  Top Layer w10: R114.1@164.44,2286.09 166.44,2284.09 R113.1@166.44,2165.73 165.76,2165.04 R115.1@165.76,2039.95 170,2035.7 v2(170,1975) 170,1914.77 R111.1@170.27,1914.51 170.01,1914.25 R116.1@170.01,1794.46 170.63,1793.84 R117.1@170.63,1661.73 170.63,1584.37 TP25.1@240,1515 ; R105.2@238.15,2775.98 238.15,2775.04 238.19,2775 375.87,2775 R106.2@378.07,2777.21 497,2777.21 R107.2@499,2775.21 499.21,2775 565,2775 690,2900 C7.1@730.32,2900 ; D2.1@481.37,4396.59 481.37,4492.07 510.46,4521.16 C23.2@532.35,4521.16 ; C13.2@485,2061.38 508.62,2061.38 612.49,1957.51 645.52,1957.51 U1.29@645.87,1957.17 689.41,1957.17 695.27,1963.02 695.27,1996.33 675.72,2015.87 646.21,2015.87 U1.26@645.87,2016.22 624.85,2016.22 U1.26@624.02,2017.06 ; C16.2@485,2181.38 485,2177.44 552.85,2109.59 575.41,2109.59 v2(580,2105) 580,2070.59 624.02,2026.57 ; C29.2@572.75,4198.67 v1@572.75,4226.23 ; D1.1@575.97,4384.59 579.35,4387.97 v1(579.35,4474) ; C31.2@661.3,4251.03 C31.2@662.74,4252.46 ; v1(663.27,4294.33) 663.27,4252.99 C31.2@662.74,4252.46 ; v1(703.48,4437.72) 705.34,4439.57 736.23,4439.57 R60.1@739.12,4442.46 ; v1(704.83,4601.86) 706.15,4600.54 737.52,4600.54 R61.1@738.84,4599.22 ; v1(705.58,4546.17) 706.19,4546.78 738.97,4546.78 C24.2@739.59,4547.39 ; v1(705.77,4392.54) 706.64,4391.67 740.43,4391.67 C22.2@741.3,4390.81 ; U2.16@717.39,4043.31 745.7,4015 805.31,4015 815.52,4025.21 ; U2.14@745.23,4071.15 791.16,4025.21 815.52,4025.21 ; C32.2@792.96,4289.88 C32.2@792.96,4285.94 ; v2(825,2995) 1019.25,2995 Y2.3@1025,2989.25 ; C25.2@842.35,4301.78 842.35,4297.85 835.53,4291.04 798.06,4291.04 C32.2@792.96,4285.94 ; v3(872.73,4058.06) 839.88,4025.21 815.52,4025.21 ; U1.15@910.63,2084.13 910.63,2034.37 935,2010 965,2010 ; C14.2@938.54,1125 938.54,1132.87 903.76,1167.65 890.42,1167.65 v2(885.83,1172.24) 885.83,1222 C17.2@880.38,1227.45 880.38,1260.38 895,1275 925,1275 950,1300 U1.63@950,1475.87 ; v2(970,1975) 969.69,1975.31 969.69,2010 ; U1.10@1009.06,2084.13 1009.06,2024.06 995,2010 969.69,2010 ; C15.2@1010.32,2320 1010.32,2274.96 1017.13,2268.15 1017.13,2196.93 969.69,2149.49 U1.12@969.69,2084.13 969.69,2014.69 965,2010 ; U2.39@1045.89,3882.04 1101.33,3826.59 1101.33,3816.03 v1(1118.84,3798.52) 1118.52,3798.52 1090,3770 1090,3752.32 C34.2@1105.27,3737.06 ; v1(1053.98,4119.36) 1073.73,4139.11 U2.56@1073.73,4140.74 U2.56@1073.73,4140.94 ; v2(1080,138.72) 1082.69,141.41 1189.64,141.41 J2.2@1192.32,144.09 ; v2@1093.43,1543.43 v2(1090,1540) 1090,1581.22 1190.35,1681.57 ; v1(1101.12,4386.32) v1@1128.68,4358.76 ; v1(1160.49,4549.43) 1182.7,4549.43 1182.7,4489.22 1201.46,4470.46 1214.58,4470.46 C40.2@1240.16,4444.88 ; U2.49@1171.16,4043.31 1214.13,4043.31 v1(1226.78,4030.66) ; 1182.7,4550.39 1239.02,4550.39 1242.62,4546.79 1292.85,4546.79 C36.2@1295.28,4549.21 1297.72,4546.77 1346.97,4546.77 C37.2@1348.43,4548.23 ; C28.2@1195.9,4260.89 1195.9,4262.85 v1(1236.05,4303) ; C30.2@1227.37,4229.4 1266.18,4268.21 v1(1274.35,4268.21) ; C40.2@1240.16,4440.94 C40.2@1240.16,4444.88 ; U1.83@1254.13,1681.57 1190.35,1681.57 ; U1.76@1255.78,1543.43 U1.76@1255.91,1543.31 ; C20.2@1258.46,4198.45 1258.46,4209.01 v1(1294.04,4244.59) ; C38.2@1291.34,4439.96 1291.34,4443.9 1284.53,4450.71 1259.3,4450.71 1257.7,4452.3 1257.1,4451.69 1246.97,4451.69 C40.2@1240.16,4444.88 ; v2(1325,1490) 1329.59,1485.41 1344.42,1485.41 1384.65,1445.18 R108.2@1384.65,1444.2 ; R77.1@1347.4,4080.65 1350.57,4080.65 v1(1368.84,4098.92) ; C26.1@1362.66,3587 v1(1362.66,3625) ; C18.2@1370,1805 1327.58,1805 1313.21,1819.37 U1.90@1254.13,1819.37 1253.79,1819.02 1202.33,1819.02 1184.5,1801.2 1184.5,1687.43 1190.35,1681.57 ; R109.2@1384.6,1533.65 1384.6,1532.67 1427.27,1490 v2(1470,1490) ; C9.1@1397.63,2010.65 C9.1@1399.81,2012.82 ; C8.1@1398.66,2073.97 C8.1@1399.69,2075 ; C10.1@1400.01,1949.68 1399.69,1950 v2(1475,1950) 1446.69,1921.68 C11.1@1446.69,1891.05 ; C9.1@1400,2015 v2@1473.02,2015 ; C8.1@1400,2075 v2@1474.67,2075 ; C21.2@1412.35,3884 1421.35,3884 v1(1457.35,3848) 1546.74,3937.39 C45.2@1587.35,3937.39 C45.2@1588.2,3936.54 ; U3.4@1443.43,4309.65 1443.43,4264.47 1450.24,4257.66 C42.2@1451.63,4257.66 ; v1(1516.77,4728.06) 1516.77,4725.43 1519.85,4722.36 1519.85,4708.3 U6.4@1520.75,4707.39 ; C27.1@1518.59,3331 1678.84,3331 R110.1@1680.12,3329.72 ; v1(1575,4305) 1575,4284.32 1590.92,4268.41 1590.92,4264.47 1597.73,4257.66 C43.2@1601.66,4257.66 ; L2.2@1583.57,4621.22 1625.13,4621.22 v1(1637.35,4609) ; C45.2@1595.19,3945.31 U5.4@1708.39,3945.31 U5.11@1775.32,3945.31 ; R110.1@1680.12,3333.66 v1@1722.79,3333.66 ; U5.5@1708.39,3925.63 1755.63,3925.63 U5.11@1775.32,3945.31 ; U5.2@1708.39,3984.69 1775.32,3984.69 U5.11@1795,3965 U5.11@1775.32,3945.31 ; v1(1724.23,3337.1) 1743.94,3356.81 1743.94,3359.59 1769.69,3385.33 1769.69,3403.03 1780,3413.35 C12.2@1780,3415.31 ; C74.2@1725,2360.47 1725.24,2360.24 v2(1835.63,2360.24) ; C47.2@1833.97,4798.03 R78.1@1833.97,4861 1833.97,4894.82 v1(1835.35,4896.19) ; U4.7@1853.79,4436.8 1854.69,4435.9 1929.1,4435.9 v1(1930,4435) ; U5.7@1881.61,3945.31 1882.52,3944.41 1914.35,3944.41 1925.09,3933.67 1925.09,3874.68 1935.84,3863.94 C46.2@1975.83,3863.94 ; v1(1977.35,3806) 1977.35,3862.42 C46.2@1975.83,3863.94 ; C44.2@2086.99,3935.84 2015.08,3863.94 C46.2@1975.83,3863.94 ; U4.18@2125.44,4334.43 2187.78,4334.43 2204.04,4350.69 2224.35,4350.69 2225,4351.33 2225,4382.96 2196.76,4411.2 U4.21@2125.44,4411.2 ; S1.4@2256.81,2671.42 2267.6,2660.63 2494.37,2660.63 2509.87,2645.13 2532.37,2645.13 C19.2@2534.76,2647.52 ; R49.1@2528.39,2732.52 2529.37,2732.52 2543.07,2718.82 2543.07,2700.75 2550,2693.82 2550,2679.33 2545.51,2674.84 2545.51,2654.33 C19.2@2538.7,2647.52 C19.2@2534.76,2647.52 ; v2(2534.76,2601.33) C19.2@2534.76,2647.52 ; v2(2635,670) 2722.7,670 C3.2@2728.82,663.88 ; v2(2635,790) 2723.22,790 C4.2@2728.82,784.39 ; v2(2635,900) 2726.32,900 C5.2@2728.82,902.5 ; v2(2635,1020) 2728.21,1020 C6.2@2728.82,1020.61 ; v1@2658.58,4547.68 D13.2@2698.11,4547.68 2698.11,4463.42 R118.1@2702.91,4458.61 ; C1.2@2668.3,310.38 2752.35,310.38 C2.2@2755.35,313.38 2821.37,313.38 J1.4@2891.3,243.45 ; R84.1@3151.38,2475 3148.88,2472.5 3097.5,2472.5 v2(3095,2470) 3099.59,2474.59 3099.59,2483.38 3203.77,2587.56 C63.1@3410,2587.56 ; R86.1@3214.57,2045.28 R86.1@3218.5,2045.28 ; C62.1@3395.32,2645 3395.32,2624.21 3399.25,2620.28 3399.25,2598.31 C63.1@3410,2587.56 ; C49.1@3529.53,2627.6 3523.03,2627.6 3482.99,2587.56 C63.1@3410,2587.56 ; U7.44@4437.36,1787.5 4561.52,1787.5 4586.52,1812.5 4662.89,1812.5 ; v2(4642.02,2263.31) 4642.82,2262.5 U7.20@4732.64,2262.5 ; 4687.89,1787.5 4662.89,1812.5 ; U7.10@4729.76,2015.37 4701.29,2015.37 4691.22,2025.45 4691.22,2074.55 4701.29,2084.63 4729.76,2084.63 U7.13@4732.64,2087.5 4962.7,2087.5 4979.48,2070.72 4979.48,2045.55 C57.2@4980.18,2044.85 ; U7.3@4732.64,1837.5 4729.76,1834.63 4685.02,1834.63 4662.89,1812.5 ; C57.2@4980.18,2045.83 4990.93,2056.58 6058.05,2056.58 C66.1@6327.38,2325.91 6337.53,2325.91 6335.05,2328.38 6335.05,2370.43 6337.53,2372.91 6335.05,2375.38 6335.05,2428.07 C61.1@6332.21,2430.91 ; C71.2@5050,249.11 5050.44,249.56 5099.56,249.56 v2(5100,250) 5149.21,250 R104.1@5153.59,245.62 ; C64.1@6135.86,1326.8 6137.94,1324.71 6137.94,1288.12 v1(6157.56,1268.5) ; C69.2@6440.8,4140.62 6469.82,4140.62 6484.91,4155.71 6525.97,4155.71 R95.1@6529.39,4152.29 v1@6529.39,4178.39 ; C67.2@6443.91,3554.24 6464.39,3554.24 6471.3,3561.15 R93.1@6514.12,3561.15 ; C68.2@6447.5,3856.24 6471.61,3880.35 6518.37,3880.35 R94.1@6520.05,3878.67 v1@6520.05,3909.76 ; C70.2@6449.75,4436.11 6477.7,4436.11 6477.7,4438.49 6495.68,4456.46 R96.1@6528.91,4456.46 v1@6528.91,4495.41 ; R93.1@6525.91,3562.46 v1@6525.91,3597.91 ; C31.2@662.74,4252.46 711.73,4252.46 726.59,4267.32 736.04,4267.32 742.86,4274.13 C33.2@742.86,4278.07 785.09,4278.07 C32.2@792.96,4285.94 ; 965,2010 969.69,2010
  Top Layer w12: U1.26@624.02,2017.06 624.02,2026.57
  Top Layer w15: 2055.67,4531.76 2084.83,4531.76 U4.26@2092.23,4539.16 ; 2058.19,4522.75 2083.04,4522.75 U4.25@2092.23,4513.57 ; v1@2207.18,4539.16 2208.38,4540.35 v1(2209.65,4540.35) ; v1@2208.17,4513.57 2209.36,4514.76 v1(2210.63,4514.76) ; v2(3008.86,2125.98) 3010.33,2127.46 R87.1@3075.79,2127.46 ; R87.1@3075.79,2128.94 R87.1@3077.76,2128.94 3081.11,2128.94 3085.42,2124.63 3085.42,2094.63 3094.42,2085.63 3148.46,2085.63 3157.24,2076.84 R85.1@3157.24,2045 R85.1@3153.31,2045 ; 4689.51,1783.46 U7.1@4753.94,1783.46
  Top Layer w17: U4.25@2092.23,4513.57 U4.25@2125.44,4513.57 v1@2208.17,4513.57 ; U4.26@2092.23,4539.16 U4.26@2125.44,4539.16 v1@2207.18,4539.16
  Top Layer w20: v2@1093.43,1539 U1.76@1280,1539
  other v1: 5680.52,436.52 3187.01,2045.28 6336.91,2372.91 2094.21,2705 3503.94,2723.43 2100,2829.21 1344.49,3104.33 1487.2,3224.41 6526.28,3600.28 6521.91,3909.91 6529.91,4179.91 572.75,4226.23 632.62,4295.77 707.42,4295.77 6529.3,4496.91 2047.24,4524.61 2657.16,4548.06 112.93,4690.35
  other v2: 721.97,1834.25 1475,2015 1475,2075
  other v3: 1769.41,3913.82 1820.59,3913.82 911.43,3953.67 977.13,3953.67 1769.41,3965 1820.59,3965 944.28,3986.52 872.73,3992.36 1015.82,3992.36 1769.41,4016.18 1820.59,4016.18 905.58,4025.21 982.97,4025.21 1015.82,4058.06 944.28,4063.91 911.43,4096.76 977.13,4096.76 1405.05,4345.09 1380.44,4364.77 1429.65,4364.77 1405.05,4384.46
  other v6: 4587.35,1316.59 4587.35,2765.41
GUI_STATUS: D8.2 U1.35 | length 506.5
  Top Layer w10: D8.2@359.83,2165.73 359.83,2109.31 400,2069.14 400,1980.28 541.22,1839.06 U1.35@645.87,1839.06
ID1: R99.2 R105.1 U1.33 | length 1088.6
  Top Layer w10: R105.1@238.15,2720.87 R99.2@238.15,2663.54 237.17,2663.54 208.54,2634.92 208.54,2486.54 437.87,2257.21 437.87,1997.4 556.85,1878.43 U1.33@645.87,1878.43
ID2: R100.2 R106.1 U1.32 | length 1044.1
  Top Layer w10: R106.1@378.07,2722.09 378.07,2662.39 R100.2@378.25,2662.21 ; R100.2@379.24,2662.21 R100.2@378.25,2662.21 ; v2(520,1975) 520,1940.56 562.45,1898.11 U1.32@645.87,1898.11 ; v2(560,2215) 349.63,2425.37 349.63,2633.59 R100.2@378.25,2662.21
  Bottom Layer w10: v2@520,1972.5 v2(520,1975) 520,2175 v2(560,2215)
ID3: R101.2 R107.1 U1.31 | length 987.7
  Top Layer w10: R101.2@499,2661 R107.1@499,2720.09 ; R101.2@500,2660 v2(590,2660) ; v2(565,1960) 567,1958 567,1928 577.2,1917.8 U1.31@645.87,1917.8
  Bottom Layer w10: 550,2080 565,2065 v2(565,1960) ; 550.13,2080 550.13,2162.88 589.87,2202.63 589.87,2536.88 590,2537 v2(590,2660)
ID4: R102.2 R108.1 U1.84 | length 419.7
  Top Layer w10: U1.84@1254.13,1701.26 1254.48,1700.91 1283.99,1700.91 1355.32,1629.59 1355.32,1512.25 1363.52,1504.04 1379.92,1504.04 1428.03,1455.93 1429.02,1455.93 1439.76,1445.18 R108.1@1439.76,1444.2 R102.2@1498.04,1444.2
ID5: R103.2 R109.1 U1.85 | length 343
  Top Layer w10: U1.85@1254.13,1720.94 1254.48,1720.6 1289.58,1720.6 1428.97,1581.21 1428.97,1544.4 R109.1@1439.72,1533.65 R103.2@1498,1533.65
"INDEXER HOME": D11.2 U1.39 | length 300.3
  Top Layer w10: D11.2@360.2,1795.61 479.36,1795.61 514.66,1760.32 U1.39@645.87,1760.32
M0/nSCS/VREF1/EN4_2: J4.2 J26.2 | length 759.8
  Top Layer w10: J4.2@2590,2495 2975,2495 J26.2@3240,2760
MANUAL_VREF: C19.1 J7.2 R44.1 R49.2 | length 367.8
  Top Layer w10: C19.1@2582.01,2647.52 2585.95,2647.52 2603.62,2665.2 R49.2@2603.62,2720.63 ; R44.1@2589.88,2812.52 2590.87,2812.52 2604.57,2798.82 2604.57,2785.83 2611.5,2778.9 2611.5,2771.22 2606.06,2765.79 2606.06,2746.22 2592.36,2732.52 R49.2@2591.38,2732.52 2605.08,2718.82 2625.16,2718.82 2638.98,2705 J7.2@2765,2705
MCU_3V3: C12.1 C14.1 C16.1 C17.1 C18.1 C63.2 D5.2 D7.2 J10.10 R1.1 R4.1 R29.1 R35.1 R44.2 R83.2 R88.2 R99.1 R100.1 R101.1 R102.1 R103.1 TP27.1 U1.25 U1.64 U1.87 U1.89 U7.42 | length 15752.7
  Top Layer w10: R99.1@238.15,2608.43 238.15,2488.23 478.19,2248.19 478.19,2231.5 491.81,2217.87 514.88,2217.87 562.75,2170 v2(660,2170) 664.59,2165.41 664.59,2155.96 713.19,2107.36 713.19,2084.73 U1.25@713.78,2084.13 713.78,1928.47 969.69,1672.56 969.69,1265.58 C17.1@931.56,1227.45 ; R100.1@379.24,2607.09 381.33,2605 v2(450,2605) 499.88,2605 R101.1@500,2604.88 ; R35.1@865,2747.72 v2(865,2820) R4.1@865,2887.28 ; C17.1@927.62,1227.45 C17.1@931.56,1227.45 ; v2(1100.39,1101.9) 1056.12,1101.9 1040.9,1117.13 1040.9,1132.87 1018.34,1155.43 1003.58,1155.43 C17.1@931.56,1227.45 ; U1.87@1254.13,1760.32 1253.79,1760.66 1224.28,1760.66 1212.72,1772.22 1212.72,1787.78 1224.28,1799.34 1253.79,1799.34 U1.89@1254.13,1799.69 1297.68,1799.69 1339.61,1757.76 C18.1@1370,1757.76 ; R102.1@1553.12,1444.24 R102.1@1553.16,1444.2 ; R29.1@1602.44,1863.27 R29.1@1609.25,1870.08 ; R29.1@1609.25,1874.02 R29.1@1609.25,1870.08 ; R29.1@1616.06,1863.27 R29.1@1609.25,1870.08 ; R83.2@3062.56,1710 v2(3190,1710) 3197.99,1717.99 D7.2@3197.99,1790 ; R88.2@3077.56,1895 v2(3135,1895) ; R1.1@3140.11,140.69 3364.2,140.69 3378.51,155 v2(3385,155) ; C63.2@3410,2532.44 3410.4,2532.04 3410.4,2492.4 v2(3410.79,2492) ; v2(3995,1705) 4130,1840 4434.86,1840 U7.42@4437.36,1837.5
  Top Layer w15: C18.1@1370,1757.76 1496.93,1757.76 R29.1@1602.44,1863.27 ; v2(1432.88,1225.39) 1553.16,1345.67 R102.1@1553.16,1444.2 ; v2(1540,3535) 1540.75,3534.25 1679.09,3534.25 1679.85,3535 1755.85,3459 1777.66,3459 1780,3456.65 C12.1@1780,3454.69 ; R103.1@1553.12,1533.65 1591.37,1533.65 1623.65,1565.94 1623.65,1855.68 R29.1@1616.06,1863.27 ; R102.1@1553.14,1444.26 R103.1@1553.14,1533.63 ; v2(2444.44,2775.09) 2488.47,2775.09 2525.91,2812.52 R44.2@2526.89,2812.52
  Top Layer w20: J10.10@896.35,3360.02 896.35,3307.01 1038.36,3165 TP27.1@1188.31,3165
  Signal Layer 1 w20: TP27.1@1188.31,3165 1628.59,3165 2018.5,2775.09 v2(2444.44,2775.09)
  Signal Layer 2 w10: v2(1432.88,1225.39) 1339.64,1132.16 1130.65,1132.16 v2(1100.39,1101.9) 1100.39,474.67 1187.58,387.48 1310.29,387.48 1397.71,300.06 3239.94,300.06 v2(3385,155)
  Signal Layer 2 w15: v2(2444.44,2775.09) 2444.44,2645.86 2521.38,2568.93 3333.86,2568.93 v2(3410.79,2492) 3410.79,2488.63 3415.04,2488.63 3725.94,2177.72 3725.94,1974.06 v2(3995,1705) 3951.76,1661.76 3238.24,1661.76 3135,1765 v2(3135,1895)
  Signal Layer 2 w20: v2(660,2170) 450,2380 v2(450,2605) 665,2820 v2(865,2820) 865,2823.79 1188.31,3147.1 TP27.1@1188.31,3165
  Bottom Layer w15: J10.10@896.35,3360.02 948.5,3412.16 948.5,3514.44 969.06,3535 v2(1540,3535)
MCU_UARTRXD: J10.8 U1.61 | length 3426.8
  Top Layer w10: v2(106.78,1352.64) 106.78,1350.09 236.87,1220 799.36,1220 910.63,1331.27 U1.61@910.63,1475.87
  Bottom Layer w10: v2(106.78,1352.64) 106.78,2470.45 J10.8@996.35,3360.02
MCU_UARTTXD: J10.6 U1.60 | length 3306.5
  Top Layer w10: v2(139.76,1458.66) 139.76,1429.54 294.31,1275 829.09,1275 890.95,1336.86 U1.60@890.95,1475.87
  Bottom Layer w10: v2(139.76,1458.66) 139.76,2403.43 J10.6@1096.35,3360.02
MODE2/IPROPI4: J4.4 J16.2 R14.1 R79.2 U7.38 | length 3936.5
  Top Layer w10: v2(2585,1070) 2585.16,1069.84 2585.16,950.16 R14.1@2585.32,950 ; R79.2@3298.04,2470 3298.04,2466.14 3299.02,2465.16 3299.02,2445.16 3349.48,2394.7 3441.29,2394.7 3502.74,2333.25 J16.2@3517.61,2333.25 ; J16.2@3502.26,2333.72 3517.14,2333.72 J16.2@3517.61,2333.25 ; v4(4080,2040) 3786.28,2333.72 3518.09,2333.72 J16.2@3517.61,2333.25 ; v4(4230,1960) 4303.69,1960 4326.19,1937.5 U7.38@4437.36,1937.5
  Top Layer w15: J4.4@2590,2395 v2(2885,2395) 2994.13,2285.87 3454.41,2285.87 J16.2@3502.26,2333.72
  Bottom Layer w10: v4(4080,2040) 4160,1960 v4(4230,1960)
  Bottom Layer w20: v2(2585,1070) 2585,1130 2885,1430 v2(2885,2395)
MODE/MODE1: J4.12 R11.1 U7.39 | length 4182.8
  Top Layer w10: R11.1@1474.76,743.45 1631.2,743.45 2512.75,1625 v2(2720,1625) ; J4.12@2590,1995 2595,2000 v2(2720,2000) 2795.13,1924.87 3147.37,1924.87 3282.91,1789.34 3282.91,1663.82 3321.74,1625 3745.1,1625 4020.22,1900.13 4275.04,1900.13 4287.41,1912.5 U7.39@4437.36,1912.5
  Bottom Layer w20: v2(2720,1625) v2(2720,2000)
MSP_DECAY0/SDI/DECAY/EN1: J8.11 U1.65 | length 3283.4
  Top Layer w10: v2(988.19,1225.39) 989.02,1226.23 989.02,1475.52 U1.65@989.37,1475.87 ; v2(2180,3060) 2280,3160 J8.11@2402.56,3160
  Bottom Layer w10: v2(988.19,1225.39) 1081.81,1131.77 1148.51,1131.77 1155.16,1125.13 1497.65,1125.13 2180,1807.47 v2(2180,3060)
MSP_DECAY1/SDO/RSVD/EN2: J8.13 U1.66 | length 3110.5
  Top Layer w10: U1.66@1009.06,1475.87 1009.06,1290.94 1044.89,1255.11 1052.14,1255.11 v2(1092.57,1214.68) ; v2(2145,2970) 2235,3060 J8.13@2402.56,3060
  Bottom Layer w10: v2(1092.57,1214.68) 1152.25,1155 1502.25,1155 2145,1797.75 v2(2145,2970)
MSP_DIR/IN2/PH2: J8.5 U1.52 | length 3334.4
  Top Layer w10: U1.52@733.46,1475.87 733.46,1539.01 725.13,1547.35 725.13,1628.63 740,1643.51 v2(740,1650) ; v2(2100,3260) 2105,3260 2155,3310 2310,3460 J8.5@2402.56,3460
  Bottom Layer w10: v2(740,1650) 764.8,1625.2 1693,1625.2 2006.1,1938.3 2006.1,3166.1 v2(2100,3260)
MSP_ENABLE/IN1/PH1: J8.3 U1.51 | length 3426
  Top Layer w10: U1.51@713.78,1475.87 713.78,1533.42 707.25,1539.95 707.25,1659.5 728.39,1680.64 752.89,1680.64 v2(778.62,1706.38) ; v2(2080,3330) 2310,3560 J8.3@2402.56,3560
  Bottom Layer w10: v2(778.62,1706.38) 823.75,1751.5 1794.03,1751.5 1988.23,1945.7 1988.23,3238.23 v2(2080,3330)
MSP_IPROPI1/IPROPI2: C10.2 R41.1 U1.98 | length 1098.8
  Top Layer w10: U1.98@1254.13,1976.85 1302.13,1976.85 1328.98,1950 1360.32,1950 1360,1950.31 1360,1974.84 1370.28,1985.13 1735.96,1985.13 1945.83,2195 R41.1@2225.32,2195
MSP_IPROPI2/IPROPI3: C9.2 R40.1 U1.99 | length 1107
  Top Layer w10: U1.99@1254.13,1996.54 1306.32,1996.54 1324.79,2015 1360.32,2015 1360,2015.31 1360,2035 1370.13,2045.13 1770.68,2045.13 2020.56,2295 R40.1@2225.32,2295
MSP_M0/nSCS/VREF1/EN4: J4.1 R54.2 TP15.1 U1.3 | length 1472.1
  Top Layer w10: U1.3@1146.85,2084.13 1147.2,2084.48 1147.2,2119.58 1299.71,2272.1 1498.48,2272.1 1554.13,2327.76 1568.87,2313.02 1610.69,2313.02 1617.63,2306.08 1643.61,2306.08 1664.85,2284.84 1839.84,2284.84 R54.2@1840,2284.69 1840.32,2285 1960,2285 2170,2495 J4.1@2392.56,2495
MSP_M1/SCLK/IN4/PH4: J8.9 R3.1 U1.54 U1.62 | length 3426.8
  Top Layer w10: R3.1@525,1382.44 726.73,1382.44 772.83,1428.54 U1.54@772.83,1475.87 773.18,1476.21 773.18,1518.5 v2(799.84,1545.16) ; v2(930,1560.13) 930.16,1559.97 930.16,1476.02 U1.62@930.32,1475.87 ; v2(2120,3085) 2295,3260 J8.9@2402.56,3260
  Bottom Layer w10: v2(799.84,1545.16) 908.54,1545.16 923.51,1560.13 v2(930,1560.13) 959.33,1589.45 1707.81,1589.45 2041.85,1923.49 2041.85,3006.85 v2(2120,3085)
MSP_M1_PD: R3.2 U1.50 | length 207.3
  Top Layer w10: R3.2@525,1437.56 525,1510 558.78,1543.78 U1.50@645.87,1543.78
MSP_MODE2/IPROPI4: C8.2 R39.1 U1.100 | length 1162.1
  Top Layer w10: U1.100@1254.13,2016.22 1299.57,2016.22 1353.5,2070.16 C8.2@1356.38,2070.16 ; R39.1@2225.32,2395 2095.28,2395 1768.19,2067.91 1524.61,2067.91 1487.65,2104.87 1387.73,2104.87 1367.13,2084.27 1367.13,2081.81 C8.2@1360.32,2075 ; C8.2@1360.32,2075 C8.2@1356.38,2075 C8.2@1360.32,2075
MSP_MODE/MODE1: J4.11 U1.67 | length 2229.2
  Top Layer w10: U1.67@1028.74,1475.87 1028.74,1321.67 1165.15,1185.26 1615.26,1185.26 1715,1285 1715,1830 1880,1995 J4.11@2392.56,1995
MSP_nFAULT: J4.15 U1.24 | length 1809.7
  Top Layer w10: U1.24@733.46,2084.13 733.46,2031.54 v2(790,1975) ; v2(1845,1870) 1920,1795 J4.15@2392.56,1795
  Bottom Layer w10: v2(790,1975) 895,1870 v2(1845,1870)
MSP_nHOME/OCPM: J4.13 U1.38 | length 1828.4
  Top Layer w10: U1.38@645.87,1780 817.25,1780 v2(818.62,1781.38) ; v2(1760,1800.13) 1764.59,1804.72 1764.59,1841.84 1832.63,1909.87 1865.13,1909.87 1880,1895 J4.13@2392.56,1895
  Bottom Layer w10: v2(818.62,1781.38) 1734.76,1781.38 1753.51,1800.13 v2(1760,1800.13)
MSP_nSCS: R54.1 U1.59 | length 1420.8
  Top Layer w10: U1.59@871.26,1475.87 871.26,1631.26 v2(900,1660) ; v2@1760.06,2245.31 R54.1@1840,2245.31
  Signal Layer 2 w10: v2(900,1660) 900,1732.25 1413.12,2245.37 v2(1760,2245.37)
MSP_nSLEEP: J8.1 U1.41 | length 3363.6
  Top Layer w10: U1.41@646.1,1720.71 708.46,1720.71 v2(736.38,1748.62) ; v2(2020,3375) 2305,3660 J8.1@2402.56,3660
  Bottom Layer w10: v2(736.38,1748.62) 827.88,1840.13 1857.37,1840.13 1970.36,1953.11 1970.36,3325.36 v2(2020,3375)
MSP_RSVD/IPROPI1: C11.2 R42.1 U1.97 | length 1123.3
  Top Layer w10: U1.97@1254.13,1957.17 1254.48,1956.82 1296.88,1956.82 1363.7,1890 1404.37,1890 1405.32,1889.05 1405.32,1865.16 1411.17,1859.3 1479.02,1859.3 1579.6,1959.87 1735.98,1959.87 1871.11,2095 R42.1@2225.32,2095
MSP_STEP/IN3/PH3: J8.7 U1.53 | length 3168.1
  Top Layer w10: U1.53@753.15,1475.87 753.5,1476.21 753.5,1508.5 755,1510 v2(755,1575) ; v2(2110,3180) 2290,3360 J8.7@2402.56,3360
  Bottom Layer w10: v2(755,1575) 787.33,1607.33 1700.41,1607.33 2023.98,1930.9 2023.98,3093.98 v2(2110,3180)
MSP_TOFF/RSVD/EN3: J8.15 R2.1 U1.22 | length 2449.4
  Top Layer w10: v2(660,2370) 660,2293.54 697.56,2255.98 R2.1@697.56,2255 697.56,2254.02 747.13,2204.45 747.13,2168.71 772.83,2143 U1.22@772.83,2084.13 ; v2(1550,2905) 1554.41,2909.41 2169.45,2909.41 2220.04,2960 J8.15@2405.12,2960
  Bottom Layer w10: v2(660,2370) 894.87,2604.87 894.87,2822.12 977.75,2905 v2(1550,2905)
MSP_TOFF_PD: R2.2 U1.23 | length 248.4
  Top Layer w10: R2.2@642.44,2255 645,2252.44 645,2220.86 650.86,2215 705,2215 725,2195 725,2165.21 753.15,2137.06 U1.23@753.15,2084.13
MSP_VREF/VREF2: J6.2 TP17.1 U1.4 | length 2066.7
  Top Layer w10: U1.4@1127.17,2084.13 1127.4,2084.37 1127.4,2127.68 1194.92,2195.19 1194.92,2331.66 1310.19,2446.93 1492.21,2446.93 TP17.1@1554.13,2508.86 ; v2(2430,2855) J6.2@2765,2855
  Signal Layer 2 w15: TP17.1@1554.13,2508.86 1554.13,2516.19 1688.43,2650.48 2225.48,2650.48 v2(2430,2855)
NetC1_1: C1.1 J1.10 TP40.1 | length 835.5
  Top Layer w10: C1.1@2668.3,357.62 2670,359.32 2670,470 2743.45,543.45 J1.10@2891.3,543.45 2934.85,587 TP40.1@3343.95,587
NetC2_1: C2.1 J1.8 TP39.1 | length 893.1
  Top Layer w10: C2.1@2755.35,360.62 2755.35,410.35 2788.45,443.45 J1.8@2891.3,443.45 2891.3,456.3 2930,495 3405,495 3456.5,546.5 TP39.1@3534.79,546.5
NetC7_2: C7.2 R4.2 U1.9 | length 1065.6
  Top Layer w10: C7.2@769.69,2900 805.49,2900 828.21,2922.72 R4.2@865,2922.72 892.8,2922.72 930,2885.51 v2(930,2815) ; U1.9@1028.74,2084.13 1028.74,2155.41 1070,2196.67 v2(1070,2235)
  Bottom Layer w10: v2(930,2815) 1074.87,2670.13 1074.87,2455 1072.75,2452.87 1072.75,2237.75 v2(1070,2235)
NetC13_1: C13.1 U1.27 | length 209.6
  Top Layer w10: C13.1@485,2108.62 485,2104.68 491.81,2097.87 511.81,2097.87 612.8,1996.88 645.52,1996.88 U1.27@645.87,1996.54
NetC15_1: C15.1 R35.2 U1.11 | length 738.7
  Top Layer w10: R35.2@865,2712.28 865,2550 v2(905,2510) ; U1.11@989.37,2084.13 989.72,2084.48 989.72,2144.24 1035,2189.53 1035,2265 1049.69,2279.69 1049.69,2320 1050,2320.31 1050,2380 v2(1025,2405)
  Bottom Layer w10: v2(905,2510) 1005.41,2409.59 1020.41,2409.59 v2(1025,2405)
NetC26_2: C26.2 J10.1 R64.2 | length 257.1
  Top Layer w10: R64.2@1203.78,3595.39 1246.96,3595.39 1255.35,3587 C26.2@1315.41,3587 ; J10.1@1296.35,3460.02 1318.73,3482.4 1318.73,3589.2 C26.2@1318.73,3592.71
NetC27_2: C27.2 J10.3 R65.2 | length 516.1
  Top Layer w10: R65.2@1104.43,3595.39 1196.35,3503.47 J10.3@1196.35,3460.02 ; v1(1424.35,3328) 1427.35,3331 C27.2@1471.35,3331
  Bottom Layer w10: J10.3@1196.35,3460.02 1249.37,3407 1328,3407 1365,3370 1365,3350 1387,3328 v1(1424.35,3328)
NetC38_1: C38.1 C40.1 R68.1 U3.1 | length 512
  Top Layer w10: R68.1@1506.39,4106.18 R68.1@1506.85,4105.73
  Top Layer w20: C40.1@1240.16,4393.7 1240.65,4393.21 1290.85,4393.21 1293.15,4390.91 1293.15,4373.67 1301.09,4365.74 v1(1301.09,4351.97) 1342.68,4310.38 1365.93,4310.38 U3.1@1366.66,4309.65 ; R68.1@1506.39,4106.18 v1(1506.39,4148.42)
  Bottom Layer w20: v1(1301.09,4351.97) 1302.85,4351.97 v1(1506.39,4148.42)
NetC39_1: C39.1 U3.3 | length 142.6
  Top Layer w10: C39.1@1347.12,4214.62 1343.44,4218.3 1343.44,4251.85 1376.56,4284.97 1402.54,4284.97 1417.84,4300.27 U3.3@1417.84,4309.65
NetC45_1: C45.1 R74.1 U5.1 | length 225.1
  Top Layer w10: R74.1@1506.07,4019.83 1533.03,4019.83 1568.22,3984.64 C45.1@1587.35,3984.64 1636.87,3984.64 1656.61,4004.37 U5.1@1708.39,4004.37
NetC46_1: C46.1 U5.8 | length 102.9
  Top Layer w10: U5.8@1881.61,3965 1948.27,3965 1969.33,3943.94 C46.1@1975.83,3943.94
NetC50_1: C50.1 U7.23 | length 342
  Top Layer w10: C50.1@4266.66,2570 C50.1@4269.53,2570 4282.48,2557.04 4282.48,2554.18 4380,2456.66 4380,2349.19 4416.69,2312.5 U7.23@4437.36,2312.5
NetC50_2: C50.2 U7.24 | length 392.8
  Top Layer w10: C50.2@4213.34,2570 4215,2568.34 4215,2480 4404.63,2290.37 4434.49,2290.37 U7.24@4437.36,2287.5
NetC51_1: C51.1 U7.22 | length 149.8
  Top Layer w15: U7.22@4746.78,2312.87 4753.68,2312.87 4819.37,2378.56 4838.17,2378.56 4855.67,2396.06 C51.1@4855.67,2402.56
NetC62_2: C62.2 J5.2 R19.2 | length 2128.5
  Top Layer w10: R19.2@2700.01,1127 2700.01,1175.01 v2(2760,1235) ; J5.2@3400,2760 3400,2711.42 3434.69,2676.74 C62.2@3434.69,2645
  Bottom Layer w20: v2(2760,1235) 2925,1400 2925,2415 3150,2640 3275,2640 3395,2760 J5.2@3400,2760
NetC72_1: C72.1 U1.13 | length 566.1
  Top Layer w10: U1.13@950,2084.13 950,2155.08 999.25,2204.33 999.25,2260.75 973.43,2286.57 973.43,2609.8 C72.1@980,2616.38
NetC72_2: C72.2 Y2.1 | length 118.8
  Top Layer w10: C72.2@980,2663.62 979.55,2664.07 979.55,2694.23 1007.28,2721.96 Y2.1@1007.28,2770.75
NetC73_1: C73.1 U1.14 | length 587.9
  Top Layer w10: U1.14@930.32,2084.13 930.32,2160.67 950.79,2181.15 v2(950.79,2213.59) ; v2(1045,2485) C73.1@1045,2616.38
  Bottom Layer w10: v2(950.79,2213.59) 1054.87,2317.68 1054.87,2468.63 1045,2478.51 v2(1045,2485)
NetC73_2: C73.2 Y2.2 | length 108.1
  Top Layer w10: Y2.2@1042.72,2770.75 1043.86,2769.61 1043.86,2664.76 C73.2@1045,2663.62
NetD1_2: D1.2 R58.1 | length 147.7
  Top Layer w10: R58.1@505.6,4197.53 505.6,4251.22 D1.2@572.03,4317.66
NetD2_2: D2.2 R59.1 | length 131.6
  Top Layer w10: R59.1@456.38,4197.53 456.38,4238.36 481.35,4263.33 481.35,4317.34 D2.2@482.35,4318.34
NetD3_2: D3.2 L1.2 | length 76.2
  Top Layer w10: L1.2@1280.45,4676.81 1298.26,4659 D3.2@1349.29,4659
NetD4_1: D4.1 Q1.3 | length 97
  Top Layer w10: Q1.3@2967.79,4497.5 2992.9,4472.39 D4.1@3054.41,4472.39
NetD5_1: D5.1 R110.2 | length 78.3
  Top Layer w10: R110.2@1680.12,3392.72 1681.35,3393.95 D5.1@1681.35,3470.5
NetD6_1: D6.1 R114.2 | length 77.5
  Top Layer w10: R114.2@219.56,2286.09 296.3,2286.09 D6.1@296.81,2285.58
NetD7_1: D7.1 R112.2 | length 75
  Top Layer w10: R112.2@3060,1790 D7.1@3135,1790
NetD8_1: D8.1 R113.2 | length 75.3
  Top Layer w10: R113.2@221.56,2165.73 D8.1@296.84,2165.73
NetD9_1: D9.1 R115.2 | length 76.4
  Top Layer w10: R115.2@220.87,2039.95 297.15,2039.95 D9.1@297.25,2040.05
NetD10_1: D10.1 R111.2 | length 71.8
  Top Layer w10: R111.2@225.38,1914.51 D10.1@297.2,1914.51
NetD11_1: D11.1 R116.2 | length 73.5
  Top Layer w10: R116.2@225.13,1794.46 226.28,1795.61 D11.1@297.2,1795.61 ; D11.1@297.32,1794.46 D11.1@298.01,1795.15
NetD12_1: D12.1 R117.2 | length 70.8
  Top Layer w10: R117.2@225.91,1661.57 R117.2@225.75,1661.73 296.14,1661.73 D12.1@296.3,1661.57
NetD13_1: D13.1 Q1.1 R97.1 | length 277.7
  Top Layer w10: D13.1@2784.72,4547.68 2824.41,4547.68 2837.18,4534.9 Q1.1@2889.05,4534.9 2894.15,4540 R97.1@3055,4540
NetF1_2: F1.2 F2.2 J12.2 TP36.1 | length 2018.1
  Top Layer w100: TP36.1@3412.59,4891.92 3794.19,4891.92 J12.2@3921.35,4764.76
  Top Layer w150: J12.2@3921.35,4358.36 3921.35,4307.06 4219.06,4009.35 F2.2@4219.06,3825 ; J12.2@3921.35,4364.76 J12.2@3921.35,4764.76
  Bottom Layer w100: J12.2@3921.35,4364.76 J12.2@3921.35,4764.76
NetJ1_6: J1.6 TP38.1 | length 478.4
  Top Layer w10: J1.6@2891.3,343.45 2947.91,400.06 3342.11,400.06 TP38.1@3345.04,403
NetJ2_4: J2.4 TP46.1 | length 478.1
  Top Layer w10: TP46.1@713.35,243 713.57,243.22 1191.07,243.22 J2.4@1191.3,243.45
NetJ4_3: J4.3 R39.2 | length 127.9
  Top Layer w10: R39.2@2264.69,2395 J4.3@2392.56,2395
NetJ4_5: J4.5 R40.2 | length 127.9
  Top Layer w10: R40.2@2264.69,2295 J4.5@2392.56,2295
NetJ4_7: J4.7 R41.2 | length 127.9
  Top Layer w10: R41.2@2264.69,2195 J4.7@2392.56,2195
NetJ4_9: J4.9 R42.2 | length 127.9
  Top Layer w10: R42.2@2264.69,2095 J4.9@2392.56,2095
NetJ9_2: J9.2 R63.2 | length 181
  Top Layer w10: R63.2@1144.43,4622.54 1144.43,4650.1 1171.05,4676.72 1171.05,4792.13 J9.2@1170.78,4792.4
NetJ9_4: J9.4 R62.2 | length 187.2
  Top Layer w10: J9.4@1070.78,4792.4 1070.6,4792.23 1070.6,4716.05 1105.06,4681.6 ; R62.2@1105.5,4618.9 1105.5,4680.99
NetJ10_5: J10.5 R66.2 | length 173.1
  Top Layer w10: R66.2@1005.34,3595.45 1096.35,3504.44 J10.5@1096.35,3460.02
NetJ10_7: J10.7 R67.2 | length 173.2
  Top Layer w10: R67.2@905.07,3595.39 996.35,3504.11 J10.7@996.35,3460.02
NetJ11_1: J11.1 L1.1 | length 249.5
  Top Layer w15: L1.1@1280.45,4739.8 1440.81,4739.8 1459.03,4758.03 J11.1@1459.03,4801.46 J11.1@1459.03,4821.41
NetJ11_5: J11.5 L2.1 | length 126.4
  Top Layer w15: J11.5@1561.39,4801.46 1562.75,4800.1 1562.75,4775.83 1562.75,4769.12 1583.57,4748.3 L2.1@1583.57,4684.22
NetJ16_1: J16.1 R79.1 R84.2 | length 337.2
  Top Layer w10: R84.2@3198.62,2475 R84.2@3200,2473.62 ; R79.1@3258.67,2470 3256.17,2472.5 3201.12,2472.5 R84.2@3200,2473.62 ; J16.1@3402.26,2333.72 3398.39,2337.6 3310.59,2337.6 3200,2448.19 R84.2@3200,2473.62
NetJ17_1: J17.1 R80.1 R85.2 | length 514.1
  Top Layer w10: R80.1@3054.69,2045 3113.94,2045 3114.23,2044.71 3114.23,2024.05 3387.04,1751.24 3387.04,1724.84 J17.1@3402.26,1709.61
NetJ18_1: J18.1 R81.1 R86.2 | length 205
  Top Layer w10: R86.2@3265.75,2045.28 3269.69,2045.28 3287.17,2027.8 3310.79,2027.8 3317.77,2020.81 3317.77,1997.61 J18.1@3402.41,1912.98
NetJ20_1: J20.1 R82.1 R87.2 | length 304.8
  Top Layer w10: J20.1@3402.26,2149.15 3394.92,2141.81 3347.73,2141.81 3341.82,2147.72 3200.38,2147.72 3192.83,2140.18 3192.83,2137.72 3180.12,2125 R82.1@3178.15,2125 3176.18,2126.97 3133.03,2126.97 R87.2@3130,2123.94 ; R87.2@3130,2123.94 R87.2@3125,2128.94 R87.2@3130,2123.94
NetJ27_2: J27.2 S1.1 | length 400.6
  Top Layer w10: J27.2@1825,2520 1825,2698.35 1975.24,2848.58 S1.1@1985,2848.58
NetQ1_2: Q1.2 R118.2 | length 131.6
  Top Layer w10: R118.2@2758.03,4458.61 2759.51,4460.1 Q1.2@2889.05,4460.1
NetTP1_1: TP1.1 U1.17 | length 226.9
  Top Layer w10: U1.17@871.26,2084.13 871.26,2152.17 902.64,2183.55 902.64,2232.97 910,2240.33 TP1.1@910,2295
NetTP2_1: TP2.1 U1.18 | length 120.6
  Top Layer w10: U1.18@851.57,2084.13 851.57,2171.57 TP2.1@875,2195
NetTP3_1: TP3.1 U1.19 | length 214.2
  Top Layer w10: U1.19@831.89,2084.13 831.89,2177.8 840,2185.91 TP3.1@840,2295
NetTP4_1: TP4.1 U1.20 | length 111.8
  Top Layer w10: TP4.1@810,2195 811.86,2193.14 811.86,2084.48 U1.20@812.2,2084.13
NetTP5_1: TP5.1 U1.21 | length 222.3
  Top Layer w10: TP5.1@765,2295 765,2200.91 792.52,2173.39 U1.21@792.52,2084.13
NetTP6_1: TP6.1 U1.42 | length 114.5
  Top Layer w10: TP6.1@535,1710 577.14,1710 585.88,1701.26 U1.42@645.87,1701.26
NetTP7_1: TP7.1 U1.44 | length 183.4
  Top Layer w10: TP7.1@470,1680 539.96,1680 558.07,1661.89 U1.44@645.87,1661.89
NetTP8_1: TP8.1 U1.45 | length 112
  Top Layer w10: TP8.1@535,1645 537.45,1642.55 645.52,1642.55 U1.45@645.87,1642.2
NetTP9_1: TP9.1 U1.46 | length 181.1
  Top Layer w10: TP9.1@470,1610 542.75,1610 555.27,1622.52 U1.46@645.87,1622.52
NetTP10_1: TP10.1 U1.55 | length 132.3
  Top Layer w10: TP10.1@765,1355 765,1392.75 792.52,1420.27 U1.55@792.52,1475.87
NetTP11_1: TP11.1 U1.56 | length 173.5
  Top Layer w10: U1.56@812.2,1475.87 812.2,1412.18 802.36,1402.34 802.36,1352.64 TP11.1@835,1320
NetTP12_1: TP12.1 U1.57 | length 91.6
  Top Layer w10: TP12.1@830,1385 831.54,1386.54 831.54,1475.52 U1.57@831.89,1475.87
NetTP13_1: TP13.1 U1.2 | length 477.1
  Top Layer w10: U1.2@1166.54,2084.13 1166.88,2084.48 1166.88,2113.99 1182.89,2130 1542.4,2130 TP13.1@1547.24,2134.84 1572.29,2134.84 TP13.1@1551.46,2134.84 ; TP13.1@1578.18,2126.21 TP13.1@1586.81,2134.84
NetTP14_1: TP14.1 U1.16 | length 715.7
  Top Layer w10: TP14.1@717.91,2689.46 717.91,2575.47 937.64,2355.74 937.64,2242.69 920.91,2225.96 920.91,2176.55 890.95,2146.58 U1.16@890.95,2084.13
NetTP16_1: TP16.1 U1.88 | length 341.7
  Top Layer w10: U1.88@1254.13,1780 1254.48,1779.65 1283.99,1779.65 1320.21,1743.43 1320.21,1730.4 1370.61,1680 TP16.1@1546.8,1680
NetTP18_1: TP18.1 U1.68 | length 276.7
  Top Layer w10: U1.68@1048.43,1475.87 1048.43,1365.81 TP18.1@1166.29,1247.95
NetTP19_1: TP19.1 U1.69 | length 226.3
  Top Layer w10: U1.69@1068.11,1475.87 1068.11,1415.55 1183.66,1300 TP19.1@1186.24,1300
NetTP20_1: TP20.1 U1.70 | length 308.3
  Top Layer w10: U1.70@1087.8,1475.87 1087.8,1421.14 1169.92,1339.02 1186.31,1339.02 1213.87,1311.45 1213.87,1296.75 1229.76,1280.86 TP20.1@1229.76,1236
NetTP21_1: TP21.1 U1.71 | length 244.4
  Top Layer w10: U1.71@1107.48,1475.87 1107.48,1426.73 1177.32,1356.89 1193.71,1356.89 1249.71,1300.89 TP21.1@1249.71,1300
NetTP22_1: TP22.1 U1.72 | length 327.8
  Top Layer w10: U1.72@1127.17,1475.87 1127.17,1432.32 1184.72,1374.76 1214.03,1374.76 1293.24,1295.56 TP22.1@1293.24,1234
NetTP23_1: TP23.1 U1.73 | length 271.6
  Top Layer w10: U1.73@1146.85,1475.87 1147.2,1475.52 1147.2,1440.42 1194.98,1392.64 1232.36,1392.64 TP23.1@1325,1300
NetTP24_1: TP24.1 U1.74 | length 348.6
  Top Layer w10: U1.74@1166.54,1475.87 1166.88,1475.52 1166.88,1446.01 1202.38,1410.51 1253.57,1410.51 1356.71,1307.38 TP24.1@1356.71,1236
NetTP26_1: TP26.1 U1.75 | length 284.4
  Top Layer w10: U1.75@1186.22,1475.87 1186.22,1459.06 1187.06,1458.23 1231.54,1458.23 TP26.1@1388.47,1301.29
nFAULT: J4.16 R6.1 R83.1 R112.1 U7.41 | length 3066.3
  Top Layer w10: J4.16@2590,1795 2999.88,1795 R112.1@3004.88,1790 3004.88,1711.57 R83.1@3005,1711.46 ; v2(3005,1595) R83.1@3005,1711.46 ; R6.1@3138.15,846.4 3139.94,848.2 3173.2,848.2 v2(3175,850) ; U7.41@4437.36,1862.5 4042.78,1862.5 3764.23,1583.96 3132.5,1583.96 R83.1@3005,1711.46
  Bottom Layer w10: v2(3005,1595) 3005,1540 3175,1370 v2(3175,850)
nHOME/OCPM: J4.14 R9.1 R88.1 U7.40 | length 4531.7
  Top Layer w10: R9.1@1474.76,138.72 1476.73,138.72 1481.57,143.57 1481.57,145.54 2965,1628.96 v2(2965,1670) ; J4.14@2590,1895 R88.1@3022.44,1895 3022.44,1894.02 3088.5,1827.96 3209.73,1827.96 3265.04,1772.66 3265.04,1654.33 3317.54,1601.83 3756.83,1601.83 4037.25,1882.25 4282.44,1882.25 4287.69,1887.5 U7.40@4437.36,1887.5
  Bottom Layer w20: v2(2965,1670) v2(2965,1895)
nSCS/M0/EN4/VREF1/VREF: J25.1 J26.1 R23.1 U7.33 | length 4616.1
  Top Layer w10: R23.1@1470.04,950 1670,950 2385,1665 v2(2680,1665) ; J25.1@3095,2860 J26.1@3240,2860 ; v2(3395,2945) 3398.17,2945 4280.67,2062.5 U7.33@4437.36,2062.5
  Bottom Layer w10: J26.1@3240,2860 3325,2945 v2(3395,2945)
  Bottom Layer w20: v2(2680,1665) 2680,2315 3095,2730 J25.1@3095,2860
nSLEEP: J8.2 R34.1 U7.25 | length 6342.3
  Top Layer w10: R34.1@1474.76,445.81 1495.81,445.81 2435,1385 v2(2435,1495) ; J8.2@2600,3660 v2(2895,3660) 3195,3660 4139.87,2715.13 4139.87,2525.13 4401.69,2263.31 4436.55,2263.31 U7.25@4437.36,2262.5
  Bottom Layer w10: v2(2435,1495) 2435,2685 2895,3145 v2(2895,3660)
PUSH: J27.3
RST/SBWTDIO: C74.1 J10.4 J27.1 R29.2 U1.96 | length 2466.1
  Top Layer w10: U1.96@1254.13,1937.48 1254.48,1937.13 1288.62,1937.13 1407.05,1818.7 1520,1818.7 1560,1858.7 1560,1915 1573.7,1928.7 1602.44,1928.7 R29.2@1609.25,1921.89 ; v2(1715,1930) 1713.7,1928.7 1616.06,1928.7 R29.2@1609.25,1921.89 ; C74.1@1725,2419.53 J27.1@1725,2520 ; R29.2@1609.25,1921.89 R29.2@1609.25,1921.26 R29.2@1609.25,1921.89
  Bottom Layer w10: J10.4@1196.35,3360.02 1679.66,2876.71 1679.66,2686.01 1725,2640.67 J27.1@1725,2520 1865.5,2379.5 1865.5,2080.5 v2(1715,1930)
RSVD/IPROPI1: J4.10 J17.2 R21.1 R80.2 U7.35 | length 3978.2
  Top Layer w10: v2(2440,765) 2440,760.25 2585,615.26 R21.1@2586.96,615.26 ; v4(4370.15,2012.82) 4370.31,2012.66 4437.2,2012.66 U7.35@4437.36,2012.5
  Top Layer w15: J4.10@2595,2095 v2(2765,2095) 2815,2045 R80.2@3017.28,2045 ; R80.2@3017.77,2044.51 3027.5,2034.78 3027.5,2028.79 3076.96,1979.33 3121.73,1979.33 3303.29,1797.77 3303.29,1678.37 3336.28,1645.37 3494.71,1645.37 3520.44,1671.11 3520.44,1677.92 3511.82,1686.54 3511.82,1701 3520.44,1709.61 J17.2@3502.26,1709.61 ; J17.2@3520.44,1709.14 3795.16,1709.14 4016.02,1930 v4(4270,1930)
  Bottom Layer w10: v4(4270,1930) 4350.21,2010.21 4367.55,2010.21 v4(4370.15,2012.82)
  Bottom Layer w20: v2(2440,765) 2440,1215 2765,1540 v2(2765,2095)
RSVD/IPROPI2/IPROPI1/IPROPI: J4.8 J18.2 J19.2 R18.1 R81.2 U7.36 | length 4273.2
  Top Layer w10: v2(2480,810) 2558.76,731.24 R18.1@2587.91,731.24 ; R81.2@3353.38,2024.57 3357.14,2024.57 3608.5,2024.57 J19.2@3655.21,1977.86 ; J18.2@3502.41,1912.98 3509.32,1912.98 3539.44,1882.86 3559.79,1882.86 3582.64,1860 3900.6,1860 4030.91,1990.32 4155.22,1990.32 4174.59,2009.68 4304.56,2009.68 4326.74,1987.5 U7.36@4437.36,1987.5
  Top Layer w15: J4.8@2590,2195 v2(3101.39,2195)
  Signal Layer 2 w15: v2(3101.39,2195) 3220.38,2195 J18.2@3502.41,1912.98 ; J18.2@3516.04,1912.5 3516.04,1926.61 3567.29,1977.86 J19.2@3655.21,1977.86 ; J18.2@3502.41,1912.98 3515.93,1912.98 J18.2@3502.41,1912.98
  Bottom Layer w15: J18.2@3502.41,1912.98 3502.88,1912.5 J18.2@3532.64,1912.5 ; J19.2@3652.71,1977.86 J19.2@3655.21,1977.86
  Bottom Layer w20: v2(2480,810) 2480,1215.58 2805,1540.58 v2(2805,2195)
RSVD/IPROPI3/IPROPI2/IPROPI: J4.6 J19.1 J20.2 R17.1 R82.2 U7.37 | length 4129.9
  Top Layer w10: v2(2555,890) 2578.5,866.5 2578.5,854.84 2583.35,850 R17.1@2585.32,850 ; R82.2@3217.52,2125 3223.43,2119.09 3334.31,2119.09 3349.61,2103.8 3451.8,2103.8 3489.79,2141.79 3497.15,2149.15 J20.2@3502.26,2149.15 3523.17,2149.15 3761,2149.15 3895.16,2015 v4(4145,2015) ; J20.2@3501.16,2142.07 3504.23,2143.06 3524.61,2149.61 3520.3,2145.3 3520.3,2131.28 3573.72,2077.86 J19.1@3655.21,2077.86 ; v4(4275,1985) 4303.96,1985 4326.09,1962.87 4436.99,1962.87 U7.37@4437.36,1962.5
  Top Layer w15: J4.6@2590,2295 v2(2845,2295) 2912.63,2227.37 3424.04,2227.37 J20.2@3502.26,2149.15
  Bottom Layer w10: v4(4145,2015) 4147.61,2017.61 4168.01,2017.61 4180.41,2030 4233.69,2030 4275,1988.69 v4(4275,1985)
  Bottom Layer w20: v2(2555,890) 2510,935 2510,1135 2845,1470 v2(2845,2295)
RSVD/TOFF/EN3: J8.16 R24.1 U7.32 | length 5512.3
  Top Layer w10: R24.1@1475.72,243.45 1477.69,243.45 1482.53,248.29 1482.53,250.26 2520,1287.73 v2(2520,1580) ; J8.16@2600,2960 2886.49,2960 2901.37,2974.87 3407.37,2974.87 4294.75,2087.5 U7.32@4437.36,2087.5
  Bottom Layer w10: v2(2520,1580) 2520,2510 2680,2670 2680,2705.86 2805,2830.86 2805,2888.17 2817.19,2900.35 2820.35,2900.35 v2(2880,2960)
RX: R70.1 U4.5 | length 105.2
  Top Layer w10: R70.1@1748.98,4488.9 1852.87,4488.9 U4.5@1853.79,4487.98
SCLK/M1/IN4/RSVD: J8.10 R27.1 U7.29 | length 4566
  Top Layer w10: J8.10@2600,3260 3265,3260 v2@3913,2612 ; R27.1@3138.15,739.12 3138.59,739.56 3204.56,739.56 v2(3205,740) ; v2(3915,2610) 4362.5,2162.5 U7.29@4437.36,2162.5
  Bottom Layer w10: v2(3205,740) 3205,1270 3970,2035 3970,2490 3915,2545 v2(3915,2610)
SDI/DECAY0/EN1/DECAY: J8.12 R26.1 U7.30 | length 5541.3
  Top Layer w10: R26.1@1469.72,638.3 1593.3,638.3 v2(2375,1420) ; J8.12@2600,3160 3272.8,3160 4295.3,2137.5 U7.30@4437.36,2137.5
  Bottom Layer w10: v2(2375,1420) 2375,2855 2509.63,2989.63 2694.63,2989.63 v2(2865,3160)
SDO/DECAY1/EN2/RSVD: J8.14 R25.1 U7.31 | length 5189.5
  Top Layer w10: R25.1@1469.04,841 1651,841 2335,1525 v2(2335,1570) ; J8.14@2600,3060 3347.53,3060 4295.03,2112.5 U7.31@4437.36,2112.5
  Bottom Layer w10: v2@2335,1575 2335,2890 2452.5,3007.5 2662.5,3007.5 v2(2715,3060)
STEP/IN3/RSVD: J8.8 R30.1 U7.28 | length 5313
  Top Layer w10: R30.1@1469.69,1090 1740,1090 v2(2305,1655) ; J8.8@2600,3360 2605,3365 2765,3365 2770,3360 2775,3365 3202.25,3365 3944.87,2622.37 3944.87,2605.68 4363.06,2187.5 U7.28@4437.36,2187.5
  Bottom Layer w10: v2(2305,1655) 2305,2900 v2(2770,3365)
T_RST_RST: R65.1 U2.43 | length 382.7
  Top Layer w10: 1113.45,3925.83 1101.57,3937.72 1188.51,3850.77 1188.51,3679.47 R65.1@1137.83,3628.8
T_TEST_TCKC: R64.1 U2.44 | length 373.2
  Top Layer w10: U2.44@1115.49,3951.64 1237.19,3829.93 R64.1@1237.19,3628.8
TB0CLK: U1.43 U1.58 | length 468.7
  Top Layer w10: U1.43@645.87,1681.57 704.05,1681.57 741.22,1718.75 748.75,1718.75 775.86,1745.86 794.14,1745.86 851.57,1688.43 U1.58@851.57,1475.87
TCK: U1.95
TDI: U1.93
TDO: U1.92
TMS: U1.94
TST/SBWTCK: J10.2 U1.91 | length 1641.3
  Top Layer w10: v2(1175,1910) 1175,1855 1190.94,1839.06 U1.91@1254.13,1839.06 ; v2(1242.35,2875.13) 1242.35,3139.31 1244.68,3141.65 1244.68,3308.83 1295.87,3360.02 J10.2@1296.35,3360.02
  Bottom Layer w10: v2(1175,1910) 1242.35,1977.35 v2(1242.35,2875.13)
TX: R69.2 U4.1 | length 107.6
  Top Layer w10: R69.2@1747.71,4594 1751.37,4590.34 U4.1@1853.79,4590.34
USB_D_N: J11.2 R72.1 R73.1 U6.2 U6.6 | length 964.6
  Top Layer w10: v1(1449.81,4703) 1454.2,4707.39 U6.6@1481.38,4707.39 1482.29,4708.3 1482.29,4718.28 1484.62,4720.61 J11.2@1484.62,4801.46 ; U6.2@1500.75,4684 1500.75,4625.62 v1(1471.14,4596) 1505.29,4561.85 R72.1@1505.29,4475.19 ; v1(1559.35,4573) 1574.78,4573 1656.12,4491.66 1656.12,4429.11 1694.73,4390.51 R73.1@1694.73,4251.15
  Bottom Layer w10: v1(1449.81,4703) 1449.81,4617.33 v1(1471.14,4596) 1536.35,4596 v1(1559.35,4573)
USB_D_P: J11.3 R71.1 R75.1 U6.3 | length 713.4
  Top Layer w10: J11.3@1510.21,4801.46 1514.07,4797.6 1514.07,4762.89 1539.53,4737.42 1539.53,4696.5 1529.67,4686.64 1521.66,4686.64 1520.75,4685.74 1520.75,4579.47 1553.72,4546.5 1553.72,4471.26 1568.41,4456.57 1570.87,4456.57 1630.29,4397.15 1630.29,4248.06 1690.17,4188.18 R71.1@1694.11,4188.18