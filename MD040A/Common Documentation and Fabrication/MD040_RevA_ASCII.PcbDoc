# Altium PCB MD040_RevA_ASCII.PcbDoc (part 4 of 6)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 5000 x 5000 mil, 4 copper layers (Top Layer, Signal Layer 1, Signal Layer 2, Bottom Layer), stack 61.2 mil thick; 342 components, 206 nets, 933 pads, 352 vias.
Unrouted connection lines stored in the file: 124.

## Components (designator, comment, footprint, x,y, rotation, side; value= is the part's Value field where it differs from the comment) (continued)
TP35 "5015" Testpoint_Keystone_Miniature 4822,2805 r90 top
TP36 "5010" Keystone5010 3409,4715.76 r0 top
TP37 "5012" Keystone5012 3510.44,341 r0 top
TP38 "5012" Keystone5012 3320.69,378 r0 top
TP39 "5012" Keystone5012 3510.44,521.5 r0 top
TP40 "5012" Keystone5012 3319.6,562 r0 top
TP41 "5012" Keystone5012 3506.81,701 r0 top
TP42 "5012" Keystone5012 3320.69,763 r0 top
TP43 "5012" Keystone5012 3507.9,879 r0 top
TP44 "5012" Keystone5012 3325,959 r0 top
TP45 "5012" Keystone5012 3509,1057 r0 top
TP46 "5012" Keystone5012 689,218 r0 top
U1 "MSP430F5338IPZ" PZT0100A_N 928.04,1942.9 r0 top
U2 "CMP-0039269-4" RGC0064B 919.92,4000.21 r315 top
U3 "TPS73533DRBR" DRB0008A 1380.69,4339.77 r90 top
U4 "FT232RL" SSOP28_N 1965.27,4399 r0 top
U5 "TPS7A4333DGQ" DGQ0010E-MFG 1763.66,3931.23 r0 top
U6 "TPD2E001DRYR" DRY0006A 1476.72,4670.58 r90 top
U7 "DRV8462DDWR" DDW0044E-MFG 3863.61,2573.33 r180 top
Y1 "CSTNR4M00GH5L000R0" MuRata_CSTNR 1095.47,4350.65 r135 top
Y2 "MS3V-T1R 32.768KHZ +/-20PPM 12.5PF" XTAL_MS3V-T1R 225.37,2028.41 r180 top
ZZ1 "This Assembly Note is for PCB labels only" AssemblyNoteLabel 196.85,5757.87 r0 top
ZZ2 "These assemblies are ESD sensitive, ESD precautions shall be observed." AssemblyNote 196.85,5639.76 r0 top
ZZ3 "These assemblies must be clean and free from flux and all contaminants. Use of no clean flux is not acceptable." AssemblyNote 196.85,5511.81 r0 top
ZZ4 "These assemblies must comply with workmanship standards IPC-A-610 Class 2, unless otherwise specified." AssemblyNote 196.85,5364.17 r0 top

## Footprints (in the part's own frame and the unit in brackets; to place one, negate y for a bottom-side part, rotate by r counter-clockwise, add the part's x,y. Pads: shape width x height; smd on the part's side, far side on the other; paste and mask are expansions set on the pad)
0402 [mm] "0402 from SM-752 data"
  rect 0.8x0.6 smd: 1(-0.6,0) 2(0.6,0)
  silkscreen extent -1.22,-0.52 1.22,0.52
0402L [mm] "0402 from SM-752 data"
  rect 0.6x0.5 smd: 1(-0.5,0) 2(0.5,0)
0603 [mm] "0603 from SM-752 data"
  rect 1x0.95 smd: 1(-0.8,0) 2(0.8,0)
  silkscreen extent -1.52,-0.69 1.52,0.69
0603_A [mm] "Chip LED, 2-Leads, Body 1.6x0.8mm, IPC Medium Density"
  rect 0.8x0.8 smd: 1(-0.8,0) 2(0.8,0)
  silkscreen extent -1.5,-0.3 -1.5,0.3
0603L [mm] "0603 from SM-752 data"
  rect 0.8x0.85 smd: 1(-0.7,0) 2(0.7,0)
  silkscreen extent -0.07,-0.33 0.07,0.33
0805_HV [mil] "0805 with 30mil clearance between pads"
  rect 50x63 smd: 1(-40,0) 2(40,0)
  silkscreen extent -74,-40 74,40
1210_220 [mm] "1210"
  rect 1.3x2.7 smd: 1(-1.45,0) 2(1.45,0)
  silkscreen extent -2.32,-1.57 2.32,1.57
3216-18 [mm] "Based on AVX recommendation in http://www.avx.com/download/software/literature/AVX-Footprint-Library.pdf"
  rrect7% 1.4x1.8 smd: 1(-1.3,0) 2(1.3,0)
  silkscreen extent -1.9,-1.12 0.8,1.12
AssemblyNote [mil] "Assembly Note"
AssemblyNoteLabel [mil] "Assembly Note for PCB Labels"
CE_Mark_5mm [mil] "Minimum text height for CE Mark"
DDW0044E-MFG [mm]
  rrect25% 1.45x0.4 smd paste+0 mask+0: 1(-3.75,6.668) 2(-3.75,6.033) 3(-3.75,5.398) 4(-3.75,4.763) 5(-3.75,4.128) 6(-3.75,3.493) 7(-3.75,2.858) 8(-3.75,2.223) 9(-3.75,1.588) 10(-3.75,0.953) 11(-3.75,0.318) 12(-3.75,-0.318) 13(-3.75,-0.953) 14(-3.75,-1.588) 15(-3.75,-2.223) 16(-3.75,-2.858) 17(-3.75,-3.493) 18(-3.75,-4.128) 19(-3.75,-4.763) 20(-3.75,-5.398) 21(-3.75,-6.033) 22(-3.75,-6.667) 23(3.75,-6.667) 24(3.75,-6.032) 25(3.75,-5.397) 26(3.75,-4.762) 27(3.75,-4.127) 28(3.75,-3.492) 29(3.75,-2.857) 30(3.75,-2.222) 31(3.75,-1.587) 32(3.75,-0.952) 33(3.75,-0.317) 34(3.75,0.318) 35(3.75,0.953) 36(3.75,1.588) 37(3.75,2.223) 38(3.75,2.858) 39(3.75,3.493) 40(3.75,4.128) 41(3.75,4.763) 42(3.75,5.398) 43(3.75,6.033) 44(3.75,6.668)
  rrect2% 5.2x14 smd paste-1000 mask+0: 45(0,0)
  silkscreen extent -5.16,-7.4 3.1,7.4
DGQ0010E-MFG [mm]
  rrect33% 1.45x0.3 smd paste+0 mask+0: 1(-2.2,1) 2(-2.2,0.5) 3(-2.2,0) 4(-2.2,-0.5) 5(-2.2,-1) 6(2.2,-1) 7(2.2,-0.5) 8(2.2,0) 9(2.2,0.5) 10(2.2,1)
  rrect5% 2.2x3.1 smd paste-1000 mask+0: 11(0,0)
  silkscreen extent -3.6,-1.65 1.65,1.65
DRB0008A [mm] "VSON-8"
  rrect32% 0.6x0.31 smd: 1(-1.4,0.975) 2(-1.4,0.325) 3(-1.4,-0.325) 4(-1.4,-0.975) 5(1.4,-0.975) 6(1.4,-0.325) 7(1.4,0.325) 8(1.4,0.975)
  rrect7% 1.5x1.75 smd paste-0.75: 9(0,0)
  silkscreen extent -1.73,-1.73 1.73,1.73
DRY0006A [mm] "USON-6"
  rrect67% 0.45x0.3 smd paste-0.05 mask+0: 1(-0.275,0.5)
  rrect67% 0.4x0.3 smd paste-0.05 mask+0: 2(-0.3,0) 3(-0.3,-0.5) 4(0.3,-0.5) 5(0.3,0) 6(0.3,0.5)
FCC_disclaimer [mil]
Fiducial10-20 [mm]
  round 1 smd mask+0: 1(0,0)
  Top Layer keep-out circle w1.178: c0,0 r0.5
FP-0603-L_1_6_0_1-W_0_8_0-IPC_B [mil]
  rect 41.64x35.91 smd paste+0 mask+0: 1(-26.66,0) 2(26.66,0)
  silkscreen extent -47,-34 47,34
FP-430481025816_SMT_SW_6MM2_6MM2-MFG [mm]
  rrect7% 2x1.4 smd paste+0 mask+0: 1(-3.5,2) 2(3.5,2) 3(-3.5,-2) 4(3.5,-2)
  silkscreen extent -5.17,-3.2 3.2,3.2
FP-691250610002_CONN_TERM_BLOCK2-MFG [mm]
  rrect4% 2.3x2.3 hole 1.5 paste-1000 mask+0: 1(-2.875,1.65)
  round 2.3 hole 1.5 paste-1000 mask+0: 2(3.475,1.65)
  silkscreen extent -7.52,-6.3 6.85,6.3
FP-691256610002_HDR2-MFG [mm]
  rrect4% 2.45x2.45 hole 1.6 paste-1000 mask+0: 1(-5.08,7.55)
  round 2.45 hole 1.6 paste-1000 mask+0: 1(-5.08,-2.61) 2(5.08,7.55) 2(5.08,-2.61)
  silkscreen extent -11,-9.2 10.21,9.2
FP-885012005058_0402-MFG [mm]
  rrect20% 0.5x0.5 smd paste+0 mask+0: 1(-0.5,0) 2(0.5,0)
  silkscreen extent -0.53,-0.63 0.53,0.63
FP-885012005080_0402-MFG [mm]
  rrect20% 0.5x0.5 smd paste+0 mask+0: 1(-0.5,0) 2(0.5,0)
  silkscreen extent -0.53,-0.63 0.53,0.63
FP-885012006085_0603-MFG [mm]
  rrect13% 0.8x0.8 smd paste+0 mask+0: 1(-0.75,0) 2(0.75,0)
  silkscreen extent -0.85,-0.77 0.85,0.77
FP-885012106008_0603-MFG [mm]
  rrect13% 0.8x0.8 smd paste+0 mask+0: 1(-0.75,0) 2(0.75,0)
  silkscreen extent -0.85,-0.77 0.85,0.77
FP-885012206120_0603-MFG [mm]
  rrect13% 0.8x0.8 smd paste+0 mask+0: 1(-0.75,0) 2(0.75,0)
  silkscreen extent -0.85,-0.77 0.85,0.77
FP-BZX84J-B4V7,115_SC90-MFG [mm]
  rrect17% 0.6x0.6 smd paste-1000 mask+0: 1(-1.1,0) 2(1.1,0)
  silkscreen extent -2.08,-0.67 0.43,0.67
FP-C0805C-DN-MFG [mm]
  rect 0.95x1.35 smd paste+0 mask+0: 1(-0.75,0) 2(0.75,0)
  silkscreen extent -1.1,-1.07 1.1,1.07
FP-CH0402-10RJFPT_0402-MFG [mm]
  rrect20% 0.5x0.65 smd paste+0 mask+0: 1(-0.45,0) 2(0.45,0)
  silkscreen extent -0.8,-0.7 0.8,0.7
FP-EMVY101ARA101MKE0S_RADIAL-MFG [mm]
  rrect4% 5.7x2.5 smd paste+0 mask+0: 1(-4.85,0) 2(4.85,0)
  silkscreen extent -8.37,-6.6 6.6,6.6
Fuse_0463 [mm] "SMD, 2-Leads, Body 10.1x3.12mm"
  rrect3% 3.25x3.43 smd: 1(-4.675,0) 2(4.675,0)
  silkscreen extent -2.6,-1.5 2.6,1.5
Harwin_D3082-05 [mm] "Shorting Plug, 10.16mm spacing, TH"
  round 1.8 hole 1.3: 1(-5.08,0) 2(5.08,0)
  silkscreen extent -3.9,-0.53 3.9,0.53
IEC_Caution_Small [mil]
  silkscreen extent -107,-93 107,92
IEC_HotSurface_Small [mil]
  silkscreen extent -107,-93 107,92
Keystone5010 [mil] "Keystone Multipurpose loops"
  round 87 hole 63: 1(0,0)
  silkscreen extent -70,-70 70,70
Keystone5011 [mil] "Keystone Multipurpose loops"
  round 87 hole 63: 1(0,0)
  silkscreen extent -70,-70 70,70
Keystone5012 [mil] "Keystone Multipurpose loops"
  round 87 hole 63: 1(0,0)
  silkscreen extent -70,-70 70,70
KEYSTONE_4822 [mil] "HEX NYLON STANDOFF 6-32, M-F"
  round 1 on Mech4: 0(0,0)
Keystone_9605 [mil] "Hex Nut,4-40 Thread, 250\" Head Dia"
Label_650x200 [mil] "Thermal Transfer Label"
  round 1 on Mech13: 0(0,0)
  silkscreen extent -325,-100 325,100
Molex_1051640001 [mm] "Receptacle, USB 2.0, Micro B, 5 Pos, 0.65mm Pitch, R/A, SMT"
  rrect22% 0.45x1.38 smd: 1(1.3,4.11) 2(0.65,4.11) 3(0,4.11) 4(-0.65,4.11) 5(-1.3,4.11)
  rrect7% 1.475x2.1 smd: 6(-2.462,3.75) 11(2.462,3.75)
  rrect100% 1.4x2.1 hole 0.6 slot 1.3 at 90 deg: 7(-3.95,1.45) 10(3.95,1.45)
  rrect7% 1.375x1.9 smd: 8(-0.938,1.45) 9(0.938,1.45)
  silkscreen extent 1.2,5.1 1.4,5.4
MuRata_CSTNR [mm] "SMD, 3-Leads, Body 4.5x2mm, Pitch 1.5mm"
  rrect25% 0.4x2.6 smd: 1(-1.5,0) 2(0,0) 3(1.5,0)
ONSC-SOD-323-2-477-02_V [mm] "SOD, 2-Leads, Body 1.7x1.25mm"
  rect 0.63x0.83 smd: 1(-1.115,0) 2(1.115,0)
  silkscreen extent -1.24,-0.67 0.4,1.09
ONSC-SOT-23-3-318-08_V [mm] "SOT23, 3-Leads, Body 2.92x1.3mm, Pitch 0.95mm"
  rect 0.9x0.8 smd: 1(-1,0.95) 2(-1,-0.95) 3(1,0)
  silkscreen extent -1.12,-1.46 0.65,2.02
PZT0100A_N [mm] "QFP, 100-Leads, Body 14x14mm, Pitch 0.50mm, IPC Medium Density"
  oval 1.45x0.3 smd: 1(-7.725,6) 2(-7.725,5.5) 3(-7.725,5) 4(-7.725,4.5) 5(-7.725,4) 6(-7.725,3.5) 7(-7.725,3) 8(-7.725,2.5) 9(-7.725,2) 10(-7.725,1.5) 11(-7.725,1) 12(-7.725,0.5) 13(-7.725,0) 14(-7.725,-0.5) 15(-7.725,-1) 16(-7.725,-1.5) 17(-7.725,-2) 18(-7.725,-2.5) 19(-7.725,-3) 20(-7.725,-3.5) 21(-7.725,-4) 22(-7.725,-4.5) 23(-7.725,-5) 24(-7.725,-5.5) 25(-7.725,-6) 51(7.725,-6) 52(7.725,-5.5) 53(7.725,-5) 54(7.725,-4.5) 55(7.725,-4) 56(7.725,-3.5) 57(7.725,-3) 58(7.725,-2.5) 59(7.725,-2) 60(7.725,-1.5) 61(7.725,-1) 62(7.725,-0.5) 63(7.725,0) 64(7.725,0.5) 65(7.725,1) 66(7.725,1.5) 67(7.725,2) 68(7.725,2.5) 69(7.725,3) 70(7.725,3.5) 71(7.725,4) 72(7.725,4.5) 73(7.725,5) 74(7.725,5.5) 75(7.725,6)
  oval 0.3x1.45 smd: 26(-6,-7.725) 27(-5.5,-7.725) 28(-5,-7.725) 29(-4.5,-7.725) 30(-4,-7.725) 31(-3.5,-7.725) 32(-3,-7.725) 33(-2.5,-7.725) 34(-2,-7.725) 35(-1.5,-7.725) 36(-1,-7.725) 37(-0.5,-7.725) 38(0,-7.725) 39(0.5,-7.725) 40(1,-7.725) 41(1.5,-7.725) 42(2,-7.725) 43(2.5,-7.725) 44(3,-7.725) 45(3.5,-7.725) 46(4,-7.725) 47(4.5,-7.725) 48(5,-7.725) 49(5.5,-7.725) 50(6,-7.725) 76(6,7.725) 77(5.5,7.725) 78(5,7.725) 79(4.5,7.725) 80(4,7.725) 81(3.5,7.725) 82(3,7.725) 83(2.5,7.725) 84(2,7.725) 85(1.5,7.725) 86(1,7.725) 87(0.5,7.725) 88(0,7.725) 89(-0.5,7.725) 90(-1,7.725) 91(-1.5,7.725) 92(-2,7.725) 93(-2.5,7.725) 94(-3,7.725) 95(-3.5,7.725) 96(-4,7.725) 97(-4.5,7.725) 98(-5,7.725) 99(-5.5,7.725) 100(-6,7.725)
  silkscreen extent -8.1,-8.2 8.1,8.2
RESC1005X40X25NL05T05 [mm] "Chip Resistor, 2-Leads, Body 1.05x0.55mm, IPC Medium Density"
  rect 0.55x0.55 smd: 1(-0.45,0) 2(0.45,0)
RGC0064B [mm] "VQFN-64"
  rrect42% 0.6x0.24 smd mask+0: 1(-4.4,3.75) 2(-4.4,3.25) 3(-4.4,2.75) 4(-4.4,2.25) 5(-4.4,1.75) 6(-4.4,1.25) 7(-4.4,0.75) 8(-4.4,0.25) 9(-4.4,-0.25) 10(-4.4,-0.75) 11(-4.4,-1.25) 12(-4.4,-1.75) 13(-4.4,-2.25) 14(-4.4,-2.75) 15(-4.4,-3.25) 16(-4.4,-3.75) 33(4.4,-3.75) 34(4.4,-3.25) 35(4.4,-2.75) 36(4.4,-2.25) 37(4.4,-1.75) 38(4.4,-1.25) 39(4.4,-0.75) 40(4.4,-0.25) 41(4.4,0.25) 42(4.4,0.75) 43(4.4,1.25) 44(4.4,1.75) 45(4.4,2.25) 46(4.4,2.75) 47(4.4,3.25) 48(4.4,3.75)
  rrect42% 0.24x0.6 smd mask+0: 17(-3.75,-4.4) 18(-3.25,-4.4) 19(-2.75,-4.4) 20(-2.25,-4.4) 21(-1.75,-4.4) 22(-1.25,-4.4) 23(-0.75,-4.4) 24(-0.25,-4.4) 25(0.25,-4.4) 26(0.75,-4.4) 27(1.25,-4.4) 28(1.75,-4.4) 29(2.25,-4.4) 30(2.75,-4.4) 31(3.25,-4.4) 32(3.75,-4.4) 49(3.75,4.4) 50(3.25,4.4) 51(2.75,4.4) 52(2.25,4.4) 53(1.75,4.4) 54(1.25,4.4) 55(0.75,4.4) 56(0.25,4.4) 57(-0.25,4.4) 58(-0.75,4.4) 59(-1.25,4.4) 60(-1.75,4.4) 61(-2.25,4.4) 62(-2.75,4.4) 63(-3.25,4.4) 64(-3.75,4.4)
  rrect2% 4.25x4.25 smd paste-2.112: 65(0,0)
Samtec_SSQ-110-03-x-D [mm] "Receptacle, 2.54mm, 10x2, TH"
  rect 1.55x1.55 hole 1.02: 1(-11.43,1.27)
  round 1.55 hole 1.02: 2(-11.43,-1.27) 3(-8.89,1.27) 4(-8.89,-1.27) 5(-6.35,1.27) 6(-6.35,-1.27) 7(-3.81,1.27) 8(-3.81,-1.27) 9(-1.27,1.27) 10(-1.27,-1.27) 11(1.27,1.27) 12(1.27,-1.27) 13(3.81,1.27) 14(3.81,-1.27) 15(6.35,1.27) 16(6.35,-1.27) 17(8.89,1.27) 18(8.89,-1.27) 19(11.43,1.27) 20(11.43,-1.27)
  silkscreen extent -12.95,-2.48 12.95,3
Samtec_TSM-108-01-x-DV [mm] "Header, 2.54mm, 8x2, SMT"
  rect 3.68x1.27 smd: 1(-2.475,8.89) 2(2.475,8.89) 3(-2.475,6.35) 4(2.475,6.35) 5(-2.475,3.81) 6(2.475,3.81) 7(-2.475,1.27) 8(2.475,1.27) 9(-2.475,-1.27) 10(2.475,-1.27) 11(-2.475,-3.81) 12(2.475,-3.81) 13(-2.475,-6.35) 14(2.475,-6.35) 15(-2.475,-8.89) 16(2.475,-8.89)
  silkscreen extent -1.65,-10.16 1.65,10.3
SSOP28_N [mm] "SOP, 28-Leads, Body 10.2x5.3mm, Pitch 0.65mm, IPC Medium Density"
  oval 2.1x0.45 smd: 1(-3.45,4.225) 2(-3.45,3.575) 3(-3.45,2.925) 4(-3.45,2.275) 5(-3.45,1.625) 6(-3.45,0.975) 7(-3.45,0.325) 8(-3.45,-0.325) 9(-3.45,-0.975) 10(-3.45,-1.625) 11(-3.45,-2.275) 12(-3.45,-2.925) 13(-3.45,-3.575) 14(-3.45,-4.225) 15(3.45,-4.225) 16(3.45,-3.575) 17(3.45,-2.925) 18(3.45,-2.275) 19(3.45,-1.625) 20(3.45,-0.975) 21(3.45,-0.325) 22(3.45,0.325) 23(3.45,0.975) 24(3.45,1.625) 25(3.45,2.275) 26(3.45,2.925) 27(3.45,3.575) 28(3.45,4.225)
  silkscreen extent -3.57,-5.3 2,5.3
Sullins_PBC02SAAN [mm] "Sullins 100mil, 1x2, 230 mil above insulator"
  rect 1.65x1.65 hole 1.016: 1(0,1.27)
  round 1.65 hole 1.016: 2(0,-1.27)
  silkscreen extent -1.37,-2.54 1.27,3.1
Testpoint_Keystone_Miniature [mil] "Miniature SMT test point"
  rect 135x70 smd: 1(0,0)
  silkscreen extent -78,-46 78,45
TI_Stacked_Overlay_Small [mil]
TP_H045P075 [mm] "TP_H0.45P0.75"
  round 0.75 hole 0.45: 1(0,0)
WEEE_Minimum [mil] "WEEElie bin"
  silkscreen extent 22,-71 54,74
WL-SMCW_GREEN [mm] "WURTH"
  rect 0.8x0.8 smd: 1(-0.8,0) 2(0.8,0)
  silkscreen extent -1.9,-0.8 1.2,0.8
WL-SMCW_RED [mm] "WURTH"
  rect 0.8x0.8 smd: 1(-0.8,0) 2(0.8,0)
  silkscreen extent -1.9,-0.8 1.2,0.8
WL-SMCW_YELLOW [mm] "WURTH"
  rect 0.8x0.8 smd: 1(-0.8,0) 2(0.8,0)
  silkscreen extent -1.9,-0.8 1.2,0.8
Wurth_60900213421 [mil] "Shunt, 2.54mm, Black"
  round 1 on Mech3: 0(0,0)
WURTH_61300311121 [mm] "Header, 2.54mm, 3x1, TH"
  rrect50% 1.65x1.65 hole 1.15: 1(-2.54,0)
  round 1.65 hole 1.15: 2(0,0) 3(2.54,0)
Wurth_61301421121 [mm] "Header, 2.54mm, 7x2, TH"
  rrect50% 1.65x1.65 hole 1.1: 1(-1.27,7.62)
  round 1.65 hole 1.1: 2(1.27,7.62) 3(-1.27,5.08) 4(1.27,5.08) 5(-1.27,2.54) 6(1.27,2.54) 7(-1.27,0) 8(1.27,0) 9(-1.27,-2.54) 10(1.27,-2.54) 11(-1.27,-5.08) 12(1.27,-5.08) 13(-1.27,-7.62) 14(1.27,-7.62)
XTAL_MS3V-T1R [mm] "Micro Crystal Switzerland recommended land pattern"
  rect 1.1x0.6 smd: 1(-2.775,0.45) 2(-2.775,-0.45)
  rect 2.4x1.5 smd: 3(2.775,0)
  silkscreen extent -1.9,-0.74 1.2,0.74

## Part data
A1 A2 A3 A4 TP13 TP14 TP15 TP16 TP17 TP37 TP38 TP39 TP40 TP41 TP42 TP43 TP44 TP45 TP46: library part CMP-0055149-1, "Test Point, Multipurpose, White, TH"
C1 C2 C3 C4 C5 C6: library part CMP-0006250-2, "CAP, CERM, 33 pF, 50 V, +/- 5%, C0G/NP0, 0402"
C7 C8 C9 C10 C11 C12 C15 C41 C62: library part CMP-0006221-1, "CAP, CERM, 0.1 uF, 10 V, +/- 20%, X5R, 0402"
C13 C29: library part CMP-0097299-1, "0.47 µF ±20% 10V Ceramic Capacitor X5R 0603 (1608 Metric)"
C14 C31: library part CMP-0084376-1, "CAP, Tantalum Polymer, 10 µF, 10 V,+/- 20%, 0.08 ohm, 3216-18 SMD"
C16 C17 C18 C21 C25 C32 C33 C34 C36 C48: library part CMP-0006221-2, "CAP, CERM, 0.1 uF, 10 V, +/- 20%, X5R, 0402"
C19 C22 C24: library part CMP-0097306-1, "33 pF ±5% 50V Ceramic Capacitor C0G, NP0 0402 (1005 Metric)"
C20: library part CMP-0006269-2, "CAP, CERM, 4.7 uF, 10 V, +/- 20%, X5R, 0402"
C23: library part CMP-0006231-2, "CAP, CERM, 1000 pF, 50 V, +/- 10%, X7R, 0402"
C26 C27 C42 C43: library part CMP-0006215-2, "CAP, CERM, 10 pF, 50 V, +/- 5%, C0G/NP0, 0402"
C28 C30 C47: library part CMP-0078875-1, "CAP, CERM, 0.22 µF, 10 V,+/- 20%, X5R, 0402"
C35 C40 C45: library part CMP-0064924-2, "CAP, CERM, 1 uF, 10 V,+/- 20%, X5R, 0402"
C37 C39 C72 C73: library part CMP-0006227-2, "CAP, CERM, 0.01 uF, 16 V, +/- 10%, X7R, 0402"
C38: library part CMP-0006825-5, "CAP, CERM, 2.2 uF, 16 V, +/- 20%, X5R, 0603"
C44: library part CMP-14477-003474-1, "Ceramic Capacitor General Use 0.1uF ±20% 100V X5R 0603"
C46: library part CMP-0008271-1, "CAP, CERM, 3.3 uF, 25 V, +/- 10%, X6S, 0805"
C49 C51: library part CMP-0007873-2, "CAP, CERM, 1 uF, 50 V, +/- 10%, X7R, 0805"
C50 C55 C63: library part CMP-0095152-1, "0.1 µF ±10% 100V Ceramic Capacitor X7R 0603 (1608 Metric)"
C52 C54 C60 C61 C64 C65 C66: library part CMP-0097311-1, "1000 pF ±5% 100V Ceramic Capacitor C0G, NP0 0603 (1608 Metric)"
C53: library part CMP-0094051-1, "100uF 100V 20% Aluminum Electrolytic Capacitors Radial, Can - SMD - 5000 Hrs @ 105°C"
C56: library part CMP-0009145-2, "CAP, CERM, 1 uF, 100 V, +/- 10%, X7R, AEC-Q200 Grade 1, 1210"
C57 C58 C59: library part CMP-0079993-1, "CAP, CERM, 0.01 µF, 100 V,+/- 10%, X7R, 0603"
C67 C68 C69 C70 C71: library part CMP-0097308-1, "100 pF ±5% 100V Ceramic Capacitor C0G, NP0 0402 (1005 Metric)"
C74: library part CMP-1036-03017-2, "CAP CER 1100PF 50V NP0 0805"
D1: library part CMP-0002947-3, "LED, Red, SMD"
D2 D5 D6 D8 D10 D10 D11 D11: library part CMP-0002894-2, "LED, Green, SMD"
D3: library part CMP-1055-00457-1, "Schottky Barrier Diode, 2-Pin SOD-323, Pb-Free, Tape and Reel"
D4: library part CMP-1426-00004-1, "SMD mono-color Chip LED, WL-SMCW, Super Red"
D7 D12 D12: library part CMP-0002893-1, "LED, Super Red, SMD"
D9 D10 D11 D12: library part CMP-0002892-3, "LED, Yellow, SMD"
D13: library part CMP-0097377-1, "Diode Zener Single 4.7V 2% 550mW Automotive 2-Pin SOD-323F T/R"
F1: library part CMP-0081016-1, "Fuse, 15 A, 250 VAC, 100 VDC, SMD"
FID1 FID2 FID3: library part CMP-0077181-1, "Fiducial mark.  There is nothing to buy or mount."
H1 H2 H3 H4: library part CMP-0003678-1, "Standoff, Hex, 1.25\"L #6-32 Nylon"
H1_Nut H2_Nut H3_Nut H4_Nut: library part CMP-0003948-1, "Small nylon hex nut, 0.10 thick with a 0.250 outside diameter and a 4-40 threading"
J1 J2: "Receptacle, 2.54mm, 10x2, Gold, TH"
J3 J9 J10: library part CMP-0086014-1, "Header, 2.54mm, 7x2, Gold, TH"
J4 J8: library part CMP-0075595-1, "Header, 2.54mm, 8x2, Gold, SMT"
J5 J6 J7 J16 J17 J18 J19 J20 J25 J26: library part CMP-0054566-1, "Header, 100mil, 2x1, Gold, TH"
J11: "Receptacle, USB 2.0, Micro B, 5 Position, R/A, SMT"
J12: library part CMP-0086764-1, "2 Position Wire to Board Terminal Block Horizontal with Board 0.400\" (10.16mm) Through Hole.  58A max."
J13 J14 J23: library part CMP-0093233-2, "2 Position Wire to Board Terminal Block Horizontal with Board 0.250\" (6.35mm) Through Hole"
J15 J21 J22 J24 J28: library part CMP-0075110-1, "1mm Uninsulated Shorting Plug, 10.16mm spacing, TH"
J27: library part CMP-0054796-4, "Header, 2.54 mm, 3x1, Gold, TH"
L1 L2: library part CMP-0081962-1, "Ferrite Bead, 150 ohm @ 100 MHz, 0.7 A, 0603"
LBL1: library part CMP-0003625-1, "Thermal Transfer Printable Labels, 0.650\" W x 0.200\" H - 10,000 per roll"
LOGO1 LOGO7: library part CMP-0074837-1, "IEC 61010-1 Hot Surface Warning"
Logo2: library part CMP-0074844-1
Logo3: library part CMP-0074838-1, "Texas Instrument Corporate Signature"
Logo4: library part CMP-0074847-1, "FCC_disclaimer"
Logo5: library part CMP-0074769-1
Logo6: library part CMP-0074836-1, "IEC 61010-1 Caution Warning"
Q1: library part CMP-1048-00779-1, "General Purpose Transistor, NPN Silicon, 3-Pin SOT-23, Pb-Free, Tape and Reel"
R1 R5 R6 R7 R8 R9 R10 R11 R12 R13 R14 R15 R16 R17 R18 R20 R21 R22 R23 R24 R25 R26 R27 R30 R32 R33 R34 R54 R62 R63 R68: library part CMP-0026992-3, "RES, 0, 5%, 0.1 W, AEC-Q200 Grade 0, 0402"
R2 R3: library part CMP-0025784-3, "RES, 330 k, 5%, 0.1 W, 0603"
R4 R35: library part CMP-0091848-1, "10 Ohms ±5% 0.05W, 1/20W Chip Resistor 0402 (1005 Metric) RF, High Frequency Thin Film"
R19 R44 R49: library part CMP-0021998-3, "RES, 10.0 k, 1%, 0.1 W, 0603"
R29 R57 R97: library part CMP-0026935-3, "RES, 47 k, 5%, 0.063 W, AEC-Q200 Grade 0, 0402"
R39 R40 R41 R42: library part CMP-0026071-2, "RES, 1.00 k, 1%, 0.063 W, 0402"
R55 R60: library part CMP-0026728-1, "RES, 220 k, 1%, 0.0625 W, 0402"
R56: library part CMP-2002-00799-3, "Chip Resistor, 240 KOhm, +/- 1%, 100 mW, -55 to 155 degC, 0402 (1005 Metric), RoHS, Tape and Reel"
R58: library part CMP-0026934-3, "RES, 470, 5%, 0.063 W, AEC-Q200 Grade 0, 0402"
R59: library part CMP-0026948-3, "RES, 560, 5%, 0.063 W, AEC-Q200 Grade 0, 0402"
R61: library part CMP-0026021-3, "RES, 150 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402"
R64 R65 R66 R67: library part CMP-0025963-2, "RES, 10.0, 1%, 0.063 W, 0402"
R69 R70: library part CMP-0025697-4, "RES, 0, 5%, 0.1 W, AEC-Q200 Grade 0, 0603"
R71 R72 R73 R75: library part CMP-0026888-3, "RES, 27, 5%, 0.063 W, AEC-Q200 Grade 0, 0402"
R74: library part CMP-2002-00429-1
R76: library part CMP-0026085-3, "RES, 1.40 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402"
R77: library part CMP-0026859-2, "RES, 1.0 M, 5%, 0.063 W, AEC-Q200 Grade 0, 0402"
R78: library part CMP-0026907-3, "RES, 33 k, 5%, 0.063 W, AEC-Q200 Grade 0, 0402"
R79 R80 R81 R82: library part CMP-0026695-1, "RES, 3.30 k, 1%, 0.1 W, AEC-Q200 Grade 0, 0402"
R83 R88: library part CMP-0025886-3, "RES, 10 k, 5%, 0.1 W, 0603"
R84 R85 R86 R87: library part CMP-0081856-1, "RES, 0, 0%, 0.2 W, AEC-Q200 Grade 0, 0402"
R89 R90 R91 R92: library part CMP-0022628-3, "RES, 86.6 k, 1%, 0.1 W, 0603"
R93 R94 R95 R96 R104: library part CMP-0022458-4, "RES, 4.99 k, 1%, 0.1 W, AEC-Q200 Grade 0, 0603"
R98: library part CMP-0025663-3, "RES, 97.6 k, 0.5%, 0.1 W, 0603"
R99 R100 R101 R102 R103 R105 R106 R107 R108 R109: library part CMP-0025886-5, "RES, 10 k, 5%, 0.1 W, 0603"
R110: library part CMP-0023183-5, "RES, 560, 1%, 0.1 W, 0603"
R111 R112 R113 R114 R115 R116 R117: "RES, 330, 5%, 0.1 W, AEC-Q200 Grade 0, 0603"
R118: library part CMP-0023129-5, "RES, 470, 1%, 0.1 W, 0603"
S1: library part CMP-0097347-1, "Tactile Switch SPST-NO Top Actuated Surface Mount"
SH-J1 SH-J2 SH-J3 SH-J4 SH-J5 SH-J6 SH-J7 SH-J8 SH-J9 SH-J10 SH-J11 SH-J12 SH-J13 SH-J14 SH-J15 SH-J16 SH-J17 SH-J18 SH-J19 SH-J20 SH-J21 SH-J22 SH-J23 SH-J24 SH-J25 SH-J26 SH-J27 SH-J28 SH-J29 SH-J30 SH-J31: library part CMP-0003761-2, "Shunt, 2.54mm, Gold, Black"
TP1 TP2 TP3 TP4 TP5 TP6 TP7 TP8 TP9 TP10 TP11 TP12 TP18 TP19 TP20 TP21 TP22 TP23 TP24 TP26: library part CMP-0003719-1, "Testpoint"
TP25 TP29: library part CMP-0055148-1, "Test Point, Multipurpose, Black, TH"
TP27 TP28 TP30 TP36: library part CMP-0055147-1, "Test Point, Multipurpose, Red, TH"
TP31 TP32 TP34 TP35: library part CMP-0055152-1, "Test Point, Miniature, SMT"
U1: library part CMP-0038879-1, "20 MHz Mixed Signal Microcontroller with 256 KB Flash, 18432 B SRAM and 74 GPIOs, -40 to 85 degC, 100-pin QFP (PZ), Green (RoHS & no Sb/Br)"
U2: "16-Bit Ultra-Low-Power Microcontroller, 128KB Flash, 8KB RAM, USB, 12Bit ADC, 2 USCIs, 32Bit HW MPY, RGC0064B (VQFN-64)"
U3: library part CMP-0036328-3, "500mA, Adjustable, Low Quiescent Current, Low-Noise, High-PSRR, Single-Output LDO Regulator, DRB0008A (VSON-8)"
U4: library part CMP-0004774-1, "USB to Serial UART, SSOP28"
U5: library part CMP-0090815-1, "LDO, Fixed Output, Dual, 3.3V, 10/12/15V, 50mA, Precision Enable, Power-Good, HVSSOP10"
U6: library part CMP-0043099-3, "Low-Capacitance 2-Channel +/-15kV ESD Protection Array for High-Speed Data Interfaces, DRY0006A (USON-6)"
U7: library part CMP-0094066-1, "Stepper Motor Driver with Automatic Microstepping, Silent step Decay Mode and Auto-torque"
Y1: library part CMP-0085483-1, "Oscillator, 4 MHz, 700 ppm, 39 pF, SMD"
Y2: library part CMP-0004566-4, "Crystal, 32.768 kHz, 12.5pF, SMD"
ZZ1: library part CMP-0003616-3
ZZ2: library part CMP-0077236-1
ZZ3: library part CMP-0077237-1
ZZ4: library part CMP-0077238-1

## Via types
v1: diameter 19.68, hole 13.78, Top Layer to Bottom Layer, tented both sides, 230 vias
v2: diameter 19.68, hole 7.87, Top Layer to Bottom Layer, 87 vias
v3: diameter 19.68, hole 13.78, Top Layer to Bottom Layer, tented bottom, 31 vias
v4: diameter 141.73, hole 141.73, Top Layer to Bottom Layer, tented both sides, 4 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point)
3.3V_COM: C41.1 U4.4 U4.17 | length 506.8
  Top Layer w10: U4.4@1829.44,4488.57 1902.43,4488.57 1965.27,4425.73 1965.27,4339.73 2021.16,4283.84 U4.17@2101.09,4283.84 2103.56,4286.31 C41.1@2200,4286.31
A12: A1.1 R5.2 U1.5 | length 8119.6
  Top Layer w10: 196.26,2585.17 A1.1@207.11,2585.17 ; A1.1@244.12,2581.6 488.25,2337.48 488.25,2163.78 551.66,2100.38 U1.5@623.91,2100.38 ; v1(3308,226) 3309.12,227.12 3345.84,227.12 3354.72,236 4347.3,236 4430.25,318.95 4430.25,509.25 4609,688 4609,1395.35 4663,1449.35 R5.2@4663,1451.31
  Signal Layer 2 w10: A1.1@244.12,2581.6 244.12,1450.88 274.26,1420.74 274.26,846.46 845.66,275.06 3258.94,275.06 v1(3308,226)
A13: A2.1 R8.2 U1.6 | length 7820.8
  Top Layer w10: A2.1@115.56,2429.33 A2.1@116.56,2428.33 ; A2.1@127.56,2455.33 264.92,2455.33 470.38,2249.88 470.38,2156.38 546.06,2080.69 U1.6@623.91,2080.69 ; v1@3307,163 3362.13,218.13 4354.71,218.13 4448.13,311.55 4448.13,489.42 4641,682.29 4641,1112.35 4647.16,1118.5 4647.16,1131.47 R8.2@4652,1136.31
  Signal Layer 2 w10: A2.1@127.56,2455.33 215.65,2367.24 215.65,879.79 933.61,161.83 3305.83,161.83 v1@3307,163
  other v1: 3307,161
A14: A3.1 R13.2 U1.7 | length 7115.8
  Top Layer w10: A3.1@325.39,2301 393.98,2301 452.5,2242.48 452.5,2148.97 539.56,2061.91 623,2061.91 U1.7@623.91,2061.01 ; v1@3346,162 3377,193 4354.86,193 4466,304.14 4466,473.42 4665,672.42 R13.2@4665,862.49
  Signal Layer 2 w10: A3.1@325.39,2301 290.13,2265.74 290.13,1713.75 292.13,1711.75 292.13,853.87 777,369 3208,369 3346,231 v1@3346,162
  other v1: 3346,161
A15: A4.1 R16.2 U1.8 | length 6872.2
  Top Layer w10: A4.1@141.53,2163.78 410.22,2163.78 532.68,2041.32 U1.8@623.91,2041.32 ; v1(3416,170.28) 4357.42,170.28 4488,300.87 4488,461.1 4585.21,558.31 R16.2@4665,558.31
  Signal Layer 1 w10: v1(719,331) 788.17,261.83 3324.45,261.83 v1(3416,170.28)
  Signal Layer 2 w10: A4.1@141.53,2163.78 141.53,2149.82 197.78,2093.56 197.78,852.22 v1(719,331)
ACCEL/DECEL: D10.2 U1.37 | length 501
  Top Layer w10: D10.2@601.14,1280.86 689.54,1369.26 716.59,1369.26 908.35,1561.02 U1.37@908.35,1638.76
AOUT1/OUT1: C52.2 C60.1 J14.1 J22.2 R89.2 TP31.1 U7.4 U7.5 U7.6 | length 779.8
  Top Layer w10: C52.2@4652,1781.62 TP31.1@4814.04,1781.62 ; J14.1@4689.82,2066.28 4689.82,1993.97 4814.04,1869.75 TP31.1@4814.04,1781.62 ; R89.2@4814.04,1613.27 TP31.1@4814.04,1781.62 ; TP31.1@4821.94,1777 4817.31,1781.62 TP31.1@4814.04,1781.62
  Bottom Layer w10: J14.1@4689.82,2066.28 4693.24,2069.7 C60.1@4693.24,2168.38
AOUT2/OUT2: C60.2 C61.2 J14.2 J24.2 R90.2 TP32.1 U7.7 U7.8 U7.9 | length 1810.9
  Top Layer w10: C61.2@4668.62,2575.07 4823.53,2575.07 TP32.1@4824,2574.6 4824,2321.28 4819,2316.28 ; J14.2@4689.82,2316.28 4819,2316.28 ; R90.2@4808.22,1326.05 4968,1485.84 4968,2245 4896.72,2316.28 4819,2316.28
  Bottom Layer w10: J14.2@4689.82,2316.28 4693.24,2312.86 C60.2@4693.24,2215.62
BOUT1/OUT3: C64.2 C65.1 J13.2 J22.1 R91.2 TP34.1 U7.17 U7.18 U7.19 | length 2860.3
  Top Layer w10: J13.2@4690,3347 4690,3483 TP34.1@4828,3621 ; R91.2@4818.48,1036.69 4819.46,1036.69 4876.92,1094.15 4885.33,1094.15 v1(4887.18,1096)
  Bottom Layer w10: C65.1@4691,3250.62 4690.5,3251.12 4690.5,3346.5 J13.2@4690,3347 4894.93,3142.07 4894.93,2124.22 4887.18,2116.48 v1(4887.18,1096)
BOUT2/OUT4: C65.2 C66.2 J13.1 J24.1 R92.2 TP35.1 U7.14 U7.15 U7.16 | length 3225.1
  Top Layer w10: C66.2@4684.53,2679.86 4684.53,2753.48 4736.05,2805 TP35.1@4822,2805 4822,3021 4746,3097 J13.1@4690,3097 ; R92.2@4819.04,726.56 4820.03,726.56 4860,766.53 v1(4860,946)
  Bottom Layer w10: C65.2@4691,3203.38 4690,3202.38 J13.1@4690,3097 4772,3097 4860,3009 v1(4860,946)
C2K_3V3: J1.1 R1.2 | length 110.6
  Top Layer w10: J1.1@2966.94,118.45 2969.7,115.69 R1.2@3076.39,115.69
C2K_AOUT1: R7.2
C2K_AOUT2: R10.2
C2K_BOUT1: R12.2
C2K_BOUT2: R15.2
C2K_DECAY0/SDI/DECAY/EN1: J2.12 R26.2 | length 286.3
  Top Layer w10: J2.12@1166.94,618.45 1214.5,666 1363.14,666 1406,623.14 R26.2@1406,613.3
C2K_DECAY1/SDO/RSVD/EN2: J2.14 R25.2 | length 280.8
  Top Layer w10: J2.14@1166.94,718.45 1166.94,721.94 1215,770 1359.31,770 R25.2@1405.31,816
C2K_DIR/IN2/PH2: J2.5 R32.2 | length 144.9
  Top Layer w10: J2.5@1266.94,318.45 1268.91,316.48 R32.2@1411.04,316.48
C2K_ENABLE/IN1/PH1: J1.9 R33.2 | length 107.8
  Top Layer w10: J1.9@2966.94,518.45 2991,518.45 2991.79,519.24 R33.2@3074.43,519.24
C2K_IPROPI1/IPROPI2: C4.1 J1.14 R18.2 TP42.1 | length 744.6
  Top Layer w10: R18.2@2602.93,706.24 2608.84,712.15 C4.1@2704.47,712.15 2710.77,718.45 J1.14@2866.94,718.45 2915.5,767 3316.69,767 TP42.1@3320.69,763
C2K_IPROPI2/IPROPI3: C5.1 J1.16 R17.2 TP43.1 | length 938.6
  Top Layer w10: R17.2@2601.98,823.65 2697.87,823.65 C5.1@2704.47,830.26 2769.54,830.26 2781.35,818.45 J1.16@2866.94,818.45 2914.5,866 3020.69,866 3033.68,879 TP43.1@3507.9,879
C2K_M0/nSCS/VREF1/EN4: J2.18 R23.2 | length 279.4
  Top Layer w10: J2.18@1166.94,918.45 1170.26,918.45 1221.81,970 1361.31,970 R23.2@1406.31,925
C2K_M1/SCLK/IN4/PH4: J1.13 R27.2 | length 109.3
  Top Layer w10: J1.13@2966.94,718.45 3070.09,718.45 R27.2@3074.43,714.12
C2K_MODE2/IPROPI4: C6.1 J1.18 R14.2 TP44.1 | length 773.6
  Top Layer w10: R14.2@2601.98,922.78 2627.57,948.37 C6.1@2704.47,948.37 2735.63,948.37 2765.55,918.45 J1.18@2866.94,918.45 2920.5,972 3150,972 3163,959 TP44.1@3325,959
C2K_MODE/MODE1: J2.13 R11.2 | length 144.1
  Top Layer w10: J2.13@1266.94,718.45 R11.2@1411.04,718.45
C2K_nFAULT: J1.15 R6.2 | length 108.7
  Top Layer w10: J1.15@2966.94,818.45 3071.47,818.45 R6.2@3074.43,821.4
C2K_nHOME/OCPM: J2.1 R9.2 | length 146.1
  Top Layer w10: J2.1@1266.94,118.45 1271.67,113.72 R9.2@1411.04,113.72
C2K_nSLEEP: J2.7 R34.2 | length 145.1
  Top Layer w10: J2.7@1266.94,418.45 1269.31,420.81 R34.2@1411.04,420.81
C2K_RSVD/IPROPI1: C3.1 J1.12 R21.2 TP41.1 | length 974.2
  Top Layer w10: R21.2@2601.98,590.26 2703.09,590.26 C3.1@2704.47,591.63 2840.13,591.63 J1.12@2866.94,618.45 2913.5,665 3035,665 3036.01,663.99 3127.84,663.99 3155.21,636.63 3192.79,636.63 3220.16,663.99 3469.79,663.99 TP41.1@3506.81,701
C2K_STEP/IN3/PH3: J2.20 R30.2 | length 291.9
  Top Layer w10: J2.20@1166.94,1018.45 1166.94,1033.43 1201.14,1067.62 1356.69,1067.62 R30.2@1408.31,1016
C2K_TOFF/RSVD/EN3: J2.3 R24.2 | length 145.1
  Top Layer w10: J2.3@1266.94,218.45 R24.2@1412,218.45
C2K_VREF: J1.20 R19.1 TP45.1 | length 851.9
  Top Layer w10: R19.1@2738.65,1102 2822.2,1018.45 J1.20@2866.94,1018.45 2866.94,1034.94 2898,1066 3461.49,1066 TP45.1@3507.5,1019.99
DIR/IN2: J8.12 R32.1 U7.40 | length 3590.6
  Top Layer w10: R32.1@1450.41,316.48 1564.48,316.48 2728.81,1480.81 v1@2728.81,1620 ; J8.12@2617.03,1945 3131.72,1945 3597.4,2410.67 U7.40@3727.93,2410.67
  Bottom Layer w10: v1(2728,1619) 2874,1765 v1(2874,1945.5)
DM: R73.2 U4.16 | length 420.9
  Top Layer w10: R73.2@1717.62,4226.15 1746.77,4197 1967.5,4197 2028.75,4258.25 U4.16@2101.09,4258.25
DP: R71.2 U4.15 | length 430.4
  Top Layer w10: R71.2@1717,4163.18 2061.53,4163.18 2101.09,4202.74 U4.15@2101.09,4232.66
DRV_ENABLE: D9.2 U1.36 | length 641.1
  Top Layer w10: D9.2@475.6,1280.24 475.6,1343 519.73,1387.13 709.19,1387.13 887.76,1565.7 887.76,1638.76 U1.36@888.67,1638.76
DVDD: C49.1 TP28.1 U7.24 | length 739.4
  Top Layer w10: TP28.1@3298,3325 3297.87,3324.87 3297.87,3260.13 3567,2991 3567,2935 3590.53,2911.47 3621,2911.47 3621,2868 3678.33,2810.67 U7.24@3727.93,2810.67
ENABLE/IN1: J8.14 R33.1 U7.41 | length 2756.1
  Top Layer w10: J8.14@2617.03,1845 v1(3044,1845) 3057,1845 3597.67,2385.67 U7.41@3727.93,2385.67 ; R33.1@3113.8,519.24 v1@3160,519.24
  Bottom Layer w10: v1(3044,1845) 3044,1225.21 3090,1179.21 3090,589.5 v1(3161,518.5)
EVM_STATUS: D6.2 U1.34 | length 815.6
  Top Layer w10: D6.2@230.07,1279.8 245.79,1295.52 267.04,1295.52 285.06,1313.53 285.06,1333.97 373.96,1422.88 694.38,1422.88 848.39,1576.89 848.39,1637.86 U1.34@849.3,1638.76
EZFET_AVBUS: C24.1 R56.1 R61.2 U2.1 | length 474.7
  Top Layer w6: R56.1@753.72,4622 753.72,4575.91 R61.2@761.62,4568 ; C24.1@756.68,4513 757.97,4514.28 R61.2@757.97,4564.34 ; 796.12,4333 U2.1@901.83,4227.3 ; R61.2@757.97,4564.34 R61.2@761.62,4568 ; R61.2@757.97,4564.34 R61.2@761.62,4568
  Top Layer w10: C24.1@756.68,4513 758.46,4511.23 774.42,4511.23 795.32,4490.32 795.32,4333.8 796.12,4333
EZFET_AVCC2ADC: C22.1 R55.1 R60.2 U2.2 | length 308.5
  Top Layer w6: R60.2@761.62,4418 R60.2@760.12,4419.5 ; R55.1@761.62,4461 758.08,4457.46 758.08,4421.54 R60.2@760.12,4419.5 ; U2.2@887.91,4213.38 778.52,4322.76 777.42,4322.76 769.29,4330.89 769.29,4331.99 758.08,4343.21 758.08,4363.61 C22.1@756.68,4365 758.08,4366.39 758.08,4417.46 R60.2@760.12,4419.5
EZFET_D_N: C42.1 R72.2 U2.52 | length 617
  Top Layer w10: U2.52@1105.05,4060.07 1108,4060.07 1108,4065.31 1112.58,4069.89 1223.18,4069.89 1304.78,4151.49 1393.35,4151.49 C42.1@1474.52,4232.66 1474.52,4396.53 R72.2@1480.94,4402.95
EZFET_D_P: C43.1 R75.2 R76.1 R77.2 U2.50 | length 675.1
  Top Layer w10: U2.50@1132.89,4032.23 1135.45,4032.23 1135.45,4037.74 1139.77,4042.05 1244.21,4042.05 R76.1@1261.18,4059.03 1261.18,4060.59 R77.2@1289.65,4089.06 1289.65,4096.64 1366.78,4096.64 1471.24,4201.1 1505.69,4201.1 1530.07,4225.47 C43.1@1530.07,4232.66 1521.9,4240.83 1521.9,4402.25 1530.07,4402.25 R75.2@1529.37,4402.95
EZFET_LED0: R58.2 U2.20 | length 397.7
  Top Layer w10: R58.2@417.14,4125.08 417.14,4121.15 423.95,4114.34 427.88,4114.34 611.69,3930.53 724.58,3930.53 U2.20@729.79,3935.74
EZFET_LED1: R59.2 U2.21 | length 504.3
  Top Layer w10: R59.2@334.39,4127.31 334.39,4123.37 341.2,4116.56 345.14,4116.56 549.03,3912.66 734.55,3912.66 U2.21@743.71,3921.82
EZFET_PUR: R76.2 U2.51 | length 282.9
  Top Layer w6: v1(1097.09,4023.93) 1118.97,4045.81 U2.51@1118.97,4046.34
  Top Layer w10: v1(1222,3959.64) 1228.6,3959.64 1270,4001.03 R76.2@1294.59,4025.62
  Bottom Layer w10: v1(1097.09,4023.93) 1127.55,4023.93 1191.85,3959.64 v1(1222,3959.64)
EZFET_RST: C23.1 J9.11 R57.1 U2.64 | length 1326
  Top Layer w10: C23.1@508,4543.4 571.22,4543.4 R57.1@572,4542.62 572,4646.64 576,4650.64 ; J9.11@646.43,4867.4 596.82,4817.8 486.16,4817.8 455.84,4787.48 455.84,4704.8 510,4650.64 576,4650.64 ; U2.64@938.02,4227.1 938.02,4227.3 949.91,4239.18 949.91,4257.23 814.52,4392.62 814.52,4616.48 780.36,4650.64 576,4650.64
EZFET_TCK: J9.7 U2.63 | length 899.5
  Top Layer w10: J9.7@842.76,4865.24 795.32,4817.8 731.18,4817.8 697.4,4784.03 697.4,4746.46 723.97,4719.89 777.38,4719.89 832.39,4664.88 832.39,4416.39 967.78,4281 967.78,4229.22 U2.63@951.94,4213.38
EZFET_TDI: J9.3 U2.61 | length 839
  Top Layer w10: U2.61@979.78,4185.54 1003.53,4209.29 1003.53,4296.6 897.4,4402.72 897.4,4482.82 903.27,4488.68 903.27,4550.87 897.4,4556.73 897.4,4788.85 922.81,4814.26 991.77,4814.26 J9.3@1042.76,4865.24
EZFET_TDO: J9.1 U2.60 | length 870.4
  Top Layer w10: U2.60@993.7,4171.62 1005.58,4183.51 1005.58,4186.06 1021.4,4201.89 1021.4,4305.6 930.28,4396.72 930.28,4683.05 929.32,4684.01 959.16,4713.84 997.4,4752.09 997.4,4786.01 1025.65,4814.26 1091.77,4814.26 J9.1@1142.76,4865.24
EZFET_TEST: J9.8 U2.59 | length 726
  Top Layer w10: J9.8@846.43,4767.4 878,4735.83 v1@878,4522 ; v1(985.79,4132.8) 985.79,4135.87 1007.52,4157.6 U2.59@1007.62,4157.7
  Bottom Layer w10: v1(878.61,4522) 878.61,4239.98 v1(985.79,4132.8)
EZFET_TMS: J9.5 U2.62 | length 852.8
  Top Layer w10: J9.5@942.76,4865.24 896.77,4819.26 827.42,4819.26 797.4,4789.23 797.4,4746.46 852.92,4690.94 852.92,4421.92 985.65,4289.19 985.65,4219.25 U2.62@965.86,4199.46
EZFET_UARTRXD: R66.1 R70.2 U2.38 | length 1321.8
  Top Layer w10: U2.38@1007.62,3843.12 1032.67,3818.06 1032.67,3702.29 1013.69,3683.31 1014.4,3682.6 R66.1@1014.4,3603.85 ; v1@1669.51,4403.25 R70.2@1669.51,4463.9
  Bottom Layer w10: v1(1034.17,3774.94) 1151.23,3892 1332,3892 1670,4230 v1(1670,4409)
EZFET_UARTTXD: R67.1 R69.1 U2.37 | length 1424.8
  Top Layer w10: R67.1@914.12,3603.8 914.12,3683.88 ; U2.37@993.7,3829.2 1005.58,3817.31 1005.58,3775.43 914.08,3683.92 ; v1(1641.53,4501) 1641.53,4535.07 1640.61,4535.98 1668.24,4563.61 R69.1@1668.24,4569 ; 914.08,3683.92 914.12,3683.88
  Bottom Layer w10: v1(1006.61,3794) 1006.68,3794 1135.89,3923.21 1318.06,3923.21 1641.53,4246.68 v1(1641.53,4501)
EZFET_USB_Shield: C47.1 J11.6 J11.7 J11.8 J11.9 J11.10 J11.11 R78.2 | length 818.9
  Top Layer w10: J11.10@1330.35,4881.19 J11.9@1448.95,4881.19 ; J11.11@1388.91,4790.63 1412.95,4814.67 1412.95,4834.85 1448.95,4870.85 J11.9@1448.95,4881.19 ; J11.8@1522.77,4881.19 J11.8@1522.77,4850.67 ; J11.7@1641.37,4881.19 1641.37,4861.5 1582.81,4802.94 J11.6@1582.81,4790.63 ; C47.1@1762.38,4773.03 1762.38,4793.53 ; R78.2@1762.38,4836 1762.38,4793.53 ; J11.9@1448.95,4881.19 1500.7,4881.19 1522.77,4859.12 J11.8@1522.77,4850.67 ; J11.8@1522.77,4850.67 1524.66,4848.78 1544.84,4848.78 1558.77,4834.85 1558.77,4814.67 J11.6@1582.81,4790.63 ; J11.6@1582.81,4790.63 1592.13,4781.31 1750.16,4781.31 1762.38,4793.53
EZFET_V18: C28.1 U2.55 | length 131.5
  Top Layer w10: U2.55@1063.29,4102.02 1104.3,4142.94 1104.3,4168.64 1116,4180.34 C28.1@1138.14,4202.49
EZFET_VBUS: C20.1 C21.1 C35.1 C36.1 C37.1 C48.1 D3.1 R56.2 U2.53 U3.5 U3.8 U4.20 U6.1 | length 2946.8
  Top Layer w6: v1(679.39,4622) R56.2@718.28,4622 ; C36.1@1281.11,4474.55 1283.68,4471.98 1283.68,4459.22 U3.8@1342.31,4400.6 ; U3.8@1342.31,4394.89 U3.8@1342.31,4400.6 ; U3.5@1419.08,4394.89 1419.08,4400.6 1410.47,4409.21 1410.47,4410.06 1402.95,4417.57 1358.44,4417.57 1350.92,4410.06 1350.92,4409.21 U3.8@1342.31,4400.6
  Top Layer w10: U2.53@1091.13,4074.18 1146.43,4127.66 ; 1147.06,4127.03 1187.68,4127.03 C20.1@1200.7,4140.04 1211.7,4129.04 v1(1250,4129.04) ; v1(1208.13,4475.17) C35.1@1235.69,4475.17 ; v1(1280.96,3969) 1354.59,3895.37 C21.1@1354.59,3892.41 ; C36.1@1281.11,4474.55 1325.14,4474.55 1334.63,4474.53 1372.03,4511.93 C48.1@1393.91,4511.93 1420.57,4538.6 v1(1423.83,4538.6) 1412.73,4549.7 D3.1@1412.73,4634 1431.28,4634 U6.1@1457.03,4659.75 ; v1@2023.71,4360.61 U4.20@2101.09,4360.61
  Bottom Layer w10: v1(679.39,4622) 682.01,4622 696.69,4607.32 706.91,4607.32 709.23,4605 1065.86,4605 1136.28,4534.58 1136.28,4513.59 1174.7,4475.17 v1(1208.13,4475.17) ; v1(1280.96,3969) 1250.87,3999.1 1247.28,3999.1 1247.28,4126.32 v1(1250,4129.04) 1292.4,4171.44 1292.4,4241.08 1237.89,4295.59 1237.89,4355.41 1421.08,4538.6 v1(1423.83,4538.6) 1423.83,4538.5 1438.54,4523.79 1824.33,4523.79 1984.39,4363.73 v1(2023.27,4363.73)
EZFET_VCC: C31.1 C32.1 C33.1 C34.1 J10.9 R55.2 R57.2 R62.1 R63.1 R68.2 R74.2 U2.11 U2.15 U2.40 | length 3241.8
  Top Layer w10: R57.2@572,4495.38 616.28,4495.38 644.79,4466.87 650.67,4466.87 655.67,4461.87 679.65,4461.87 v1(680.52,4461) R55.2@710.44,4461 ; C31.1@579.07,4123.37 662.04,4123.37 ; C31.1@608.09,4122.86 608.09,4080.57 v1(608.6,4080.06) 659.12,4080.06 U2.15@706.96,4032.23 ; C33.1@679.13,4202.53 736.16,4202.53 C32.1@741.58,4207.95 ; C33.1@687.01,4198.59 687.01,4183.68 675,4171.68 675,4127.31 671.07,4123.37 662.04,4123.37 ; U2.11@762.63,4087.9 742.49,4108.05 690.33,4108.05 675,4123.37 662.04,4123.37 ; v1(953,4558) 1077.69,4558 R62.1@1081.15,4554.53 R63.1@1122.53,4554.53 ; U2.40@1035.46,3870.96 1052.74,3853.67 1076.98,3853.67 1105.65,3825 1107.6,3825 v1(1125.86,3806.74) 1125.86,3756.99 C34.1@1114.32,3745.46 ; v1(1446.28,3948.24) R74.2@1446.28,3994.83 ; R74.2@1450,3998.55 R74.2@1446.28,3994.83 ; R68.2@1482.5,4041.36 1446.28,4005.14 R74.2@1446.28,3994.83
  Bottom Layer w10: v1(608.6,4080.06) 676.72,4080.06 1066.69,3690.09 ; v1(675,4169.05) 675,4195.35 718.5,4238.85 718.5,4460.76 724.61,4466.87 ; v1(680.52,4461) 682.37,4462.85 700.6,4462.85 704.61,4466.87 724.61,4466.87 ; J10.9@871.53,3435.02 881.85,3445.34 881.85,3482.5 1066.69,3667.34 1066.69,3690.09 ; v1(953,4558) 853.14,4558 762.02,4466.87 724.61,4466.87 ; v1(1446.28,3948.24) 1304.78,3806.74 v1(1125.86,3806.74) 1125.86,3749.26 1066.69,3690.09
EZFET_Vcore: C29.1 U2.17 | length 270.1
  Top Layer w10: C29.1@486.58,4130.27 486.58,4126.34 493.39,4119.53 497.33,4119.53 634.74,3982.12 U2.17@693.04,3982.12
EZFET_VREF: C25.1 U2.9 | length 108
  Top Layer w10: U2.9@790.47,4115.94 773.64,4132.77 773.64,4160.47 790.37,4177.2 790.37,4203 C25.1@795.32,4207.95
EZFET_VUSB: C30.1 U2.54 | length 124
  Top Layer w10: U2.54@1077.21,4088.1 1125.07,4135.87 C30.1@1165.67,4174.93
EZFET_XT2IN: U2.57 Y1.1 | length 201.2
  Top Layer w10: U2.57@1035.46,4129.86 1061.02,4155.43 1061.02,4231.4 Y1.1@1124.02,4294.39
EZFET_XT2OUT: U2.58 Y1.3 | length 234
  Top Layer w10: U2.58@1021.54,4143.78 1040.69,4162.93 1040.69,4318.67 1029.53,4329.83 Y1.3@1029.53,4365.26
FAULT: D12.2 U1.40 | length 403.4
  Top Layer w10: D12.2@854.91,1282.01 854.91,1457.01 966.5,1568.61 966.5,1637.86 U1.40@967.41,1638.76